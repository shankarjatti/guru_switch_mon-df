options:
  parameters:
    author: shankar
    comment: |-
      MON mode: 4 TwinRX channels, each on its OWN internal LO, one band each.
      GNU Radio 3.8 / UHD 3.15. Everything shown is measured on the RX.
    description: 'Monitoring: 4 independent LOs'
    generate_options: qt_gui
    id: guru_mon
    output_language: python
    title: 'Guru MON: USRP-2945, every channel its own LO and band (monitoring)'
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: subdev
  id: variable
  parameters:
    value: '''A:0 A:1 B:0 B:1'''
  states: {}
- name: imports
  id: import
  parameters:
    imports: import mon_tools
  states: {}
- name: tone_band
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,2
    label: LAB TONE (HackRF) BAND - only tells the HackRF where to send
    type: real
    num_opts: '4'
    value: '2400000000.0'
    orient: Qt.QHBoxLayout
    option0: '900000000.0'
    label0: 900 MHz (ch0)
    option1: '2400000000.0'
    label1: 2400 MHz (ch1)
    option2: '5200000000.0'
    label2: 5200 MHz (ch2)
    option3: '5800000000.0'
    label3: 5800 MHz (ch3)
  states: {}
- name: tx_state
  id: variable_qtgui_label
  parameters:
    comment: The HackRF's own reply to the band request (UDP 'freq'). Not a measurement.
    gui_hint: 0,2,1,2
    label: TRANSMITTER
    type: string
    value: mon_tools.tx_freq(tone_band)
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '''RX1'''
    ant1: '''RX2'''
    ant2: '''RX1'''
    ant3: '''RX2'''
    center_freq0: f0
    center_freq1: f1
    center_freq2: f2
    center_freq3: f3
    clock_rate: 200e6
    clock_source0: internal
    comment: 'MON: every channel its OWN internal LO, export off (set again, in order, by mon_tools.mon_setup before the start: the TwinRX keeps the last program''s routing)'
    dc_offs_enb0: ''
    dc_offs_enb1: ''
    dc_offs_enb2: ''
    dc_offs_enb3: ''
    dev_addr: '"addr=192.168.10.2"'
    dev_args: '""'
    gain0: g0
    gain1: g1
    gain2: g2
    gain3: g3
    iq_imbal_enb0: ''
    iq_imbal_enb1: ''
    iq_imbal_enb2: ''
    iq_imbal_enb3: ''
    lo_export1: 'False'
    lo_export2: 'False'
    lo_export3: 'False'
    lo_source1: internal
    lo_source2: internal
    lo_source3: internal
    nchan: '4'
    norm_gain0: 'False'
    norm_gain1: 'False'
    norm_gain2: 'False'
    norm_gain3: 'False'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sd_spec0: subdev
    show_lo_controls: 'True'
    sync: none
    time_source0: internal
    type: fc32
  states: {}
- name: mon_meter
  id: epy_block
  parameters:
    _source_code: |
      """MON meter: counts EVERY sample of each channel (real count, not a rate x time),
      counts stream breaks (UHD tags each restart after an overflow with rx_time), and
      on request keeps the newest `keep` samples of each channel for the readout."""
      import time

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self, nch=4, keep=8192):
              gr.sync_block.__init__(self, name="MON meter", in_sig=[np.complex64] * nch, out_sig=None)
              self.nch, self.keep = nch, keep
              self.count = [0] * nch
              self.rx_time_tags = [0] * nch
              self.t_first = None
              self._buf = [[] for _ in range(nch)]
              self._have = [0] * nch
              self.snap = [None] * nch
              self._want = [True] * nch
              self._key = pmt.intern("rx_time")

          def request(self):
              for c in range(self.nch):
                  self._want[c] = True

          def work(self, input_items, output_items):
              n = len(input_items[0])
              if self.t_first is None:
                  self.t_first = time.monotonic()
              w0 = self.nitems_read(0)
              for c in range(self.nch):
                  self.count[c] += n
                  self.rx_time_tags[c] += len(self.get_tags_in_range(c, w0, w0 + n, self._key))
                  if self._want[c]:
                      x = input_items[c]
                      self._buf[c].append(x.copy())
                      self._have[c] += len(x)
                      if self._have[c] >= self.keep:
                          self.snap[c] = np.concatenate(self._buf[c])[-self.keep:]
                          self._buf[c], self._have[c], self._want[c] = [], 0, False
              return n
    nch: '4'
    keep: '8192'
  states: {}
- name: g0
  id: variable_qtgui_range
  parameters:
    comment: TwinRX gain 0..93 dB
    gui_hint: 2,0,1,1
    label: ch0 RX gain (dB)
    min_len: '100'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '93'
    value: '40.0'
  states: {}
- name: f0
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,1,1,1
    label: ch0 frequency (Hz)
    type: real
    value: '900000000.0'
  states: {}
- name: mon0
  id: variable_qtgui_label
  parameters:
    comment: set by the MON poll (snippet)
    gui_hint: 1,0,1,2
    label: LO0  ch0 A/RX1
    type: string
    value: '''starting'''
  states: {}
- name: spec0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: f0
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 3,0,2,1
    label1: ch0 A/RX1
    name: '"LO0 ch0 - spectrum"'
    type: complex
    width1: '2'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
  states: {}
- name: time0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: 3,1,2,1
    label1: I
    label2: Q
    name: '"LO0 ch0 - time (real samples, I and Q)"'
    size: '400'
    srate: samp_rate
    type: complex
    width1: '2'
    width2: '2'
    ymax: '0.1'
    ymin: '-0.1'
  states: {}
- name: g1
  id: variable_qtgui_range
  parameters:
    comment: TwinRX gain 0..93 dB
    gui_hint: 2,2,1,1
    label: ch1 RX gain (dB)
    min_len: '100'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '93'
    value: '46.0'
  states: {}
- name: f1
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,3,1,1
    label: ch1 frequency (Hz)
    type: real
    value: '2400000000.0'
  states: {}
- name: mon1
  id: variable_qtgui_label
  parameters:
    comment: set by the MON poll (snippet)
    gui_hint: 1,2,1,2
    label: LO1  ch1 A/RX2
    type: string
    value: '''starting'''
  states: {}
- name: spec1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: f1
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 3,2,2,1
    label1: ch1 A/RX2
    name: '"LO1 ch1 - spectrum"'
    type: complex
    width1: '2'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
  states: {}
- name: time1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: 3,3,2,1
    label1: I
    label2: Q
    name: '"LO1 ch1 - time (real samples, I and Q)"'
    size: '400'
    srate: samp_rate
    type: complex
    width1: '2'
    width2: '2'
    ymax: '0.1'
    ymin: '-0.1'
  states: {}
- name: g2
  id: variable_qtgui_range
  parameters:
    comment: TwinRX gain 0..93 dB
    gui_hint: 6,0,1,1
    label: ch2 RX gain (dB)
    min_len: '100'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '93'
    value: '60.0'
  states: {}
- name: f2
  id: variable_qtgui_entry
  parameters:
    gui_hint: 6,1,1,1
    label: ch2 frequency (Hz)
    type: real
    value: '5200000000.0'
  states: {}
- name: mon2
  id: variable_qtgui_label
  parameters:
    comment: set by the MON poll (snippet)
    gui_hint: 5,0,1,2
    label: LO2  ch2 B/RX1
    type: string
    value: '''starting'''
  states: {}
- name: spec2
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: f2
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 7,0,2,1
    label1: ch2 B/RX1
    name: '"LO2 ch2 - spectrum"'
    type: complex
    width1: '2'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
  states: {}
- name: time2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: 7,1,2,1
    label1: I
    label2: Q
    name: '"LO2 ch2 - time (real samples, I and Q)"'
    size: '400'
    srate: samp_rate
    type: complex
    width1: '2'
    width2: '2'
    ymax: '0.1'
    ymin: '-0.1'
  states: {}
- name: g3
  id: variable_qtgui_range
  parameters:
    comment: TwinRX gain 0..93 dB
    gui_hint: 6,2,1,1
    label: ch3 RX gain (dB)
    min_len: '100'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '93'
    value: '69.0'
  states: {}
- name: f3
  id: variable_qtgui_entry
  parameters:
    gui_hint: 6,3,1,1
    label: ch3 frequency (Hz)
    type: real
    value: '5800000000.0'
  states: {}
- name: mon3
  id: variable_qtgui_label
  parameters:
    comment: set by the MON poll (snippet)
    gui_hint: 5,2,1,2
    label: LO3  ch3 B/RX2
    type: string
    value: '''starting'''
  states: {}
- name: spec3
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: f3
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 7,2,2,1
    label1: ch3 B/RX2
    name: '"LO3 ch3 - spectrum"'
    type: complex
    width1: '2'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
  states: {}
- name: time3
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: 7,3,2,1
    label1: I
    label2: Q
    name: '"LO3 ch3 - time (real samples, I and Q)"'
    size: '400'
    srate: samp_rate
    type: complex
    width1: '2'
    width2: '2'
    ymax: '0.1'
    ymin: '-0.1'
  states: {}
- name: snippet_mon_setup
  id: snippet
  parameters:
    section: main_after_init
    code: |
      # MON mode, in order: export off, all LOs internal, tune each channel twice
      self._mon_setup = mon_tools.mon_setup(self.uhd_usrp_source_0, [self.f0, self.f1, self.f2, self.f3], [self.g0, self.g1, self.g2, self.g3])
  states: {}
- name: snippet_mon_poll
  id: snippet
  parameters:
    section: main_after_start
    code: |
      # Twice a second: every channel's own lock sensor, samples counted, stream
      # breaks, strongest line of the newest 8192 samples, ADC peak. Every 5 s the
      # same line goes to the log.
      import time
      from PyQt5 import QtCore

      self._mon_last_log = 0.0
      FS = float(self.samp_rate)

      def _mon_poll():
          m = self.mon_meter
          now = time.monotonic()
          el = (now - m.t_first) if m.t_first else 0.0
          log = now - self._mon_last_log >= 5.0
          for c in range(4):
              lk = mon_tools.lo_locked(self.uhd_usrp_source_0, c)
              lock = "LOCKED" if lk else ("LOCK UNKNOWN" if lk is None else "NOT LOCKED")
              brk = max(m.rx_time_tags[c] - 1, 0)
              txt = "%s | %.4f GHz | samples %d (%.3f MS/s) | stream breaks %d" % (
                  lock, self.uhd_usrp_source_0.get_center_freq(c) / 1e9, m.count[c],
                  (m.count[c] / el / 1e6) if el > 0 else 0.0, brk)
              x = m.snap[c]
              if x is not None:
                  r = mon_tools.readout(x, FS)
                  txt += " | newest %d samples: %s %+.1f kHz %.1f dB | ADC peak %.3f%s" % (len(x),
                      "TONE" if r["tone"] else "no tone, strongest line", r["f"] / 1e3, r["db"],
                      r["peak"], "  OVERLOAD" if r["peak"] > 0.5 else "")
              getattr(self, "set_mon%d" % c)(txt)
              if log:
                  print("[mon] %s ch%d %s" % (time.strftime("%H:%M:%S"), c, txt))
          if log:
              self._mon_last_log = now
          m.request()

      self._mon_timer = QtCore.QTimer()
      self._mon_timer.timeout.connect(_mon_poll)
      self._mon_timer.start(500)
  states: {}

connections:
- [uhd_usrp_source_0, '0', spec0, '0']
- [uhd_usrp_source_0, '0', time0, '0']
- [uhd_usrp_source_0, '0', mon_meter, '0']
- [uhd_usrp_source_0, '1', spec1, '0']
- [uhd_usrp_source_0, '1', time1, '0']
- [uhd_usrp_source_0, '1', mon_meter, '1']
- [uhd_usrp_source_0, '2', spec2, '0']
- [uhd_usrp_source_0, '2', time2, '0']
- [uhd_usrp_source_0, '2', mon_meter, '2']
- [uhd_usrp_source_0, '3', spec3, '0']
- [uhd_usrp_source_0, '3', time3, '0']
- [uhd_usrp_source_0, '3', mon_meter, '3']

metadata:
  file_format: 1
