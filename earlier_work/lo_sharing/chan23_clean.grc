options:
  parameters:
    author: shankar
    comment: |
      USRP-2945 (X310 + 2x TwinRX).  Focus on ch2/ch3 (RF B), the two channels
      confirmed receiving on this unit.

      LO routing follows gr-doa twinrx_usrp_source.py's topology (one synth
      exported, companion on same board, external on the other) but MIRRORED:
      Rx B exports, because the A->B jumpers on this unit pass no LO.

      Per channel:  DC Blocker  ->  phase-alignment resampler  ->  AGC2
        DC Blocker : removes residual DC/LO leakage after UHD's own correction
        AGC2       : holds a constant output amplitude over time
    description: TwinRX LO sharing / phase coherence test bench
    generate_options: qt_gui
    id: chan23_clean
    output_language: python
    title: Ch2/Ch3 Clean Signal - DC corrected + amplitude normalised (gr-doa reference)
  states: {}

blocks:
- name: avg_len
  id: variable
  parameters:
    comment: |-
      Coherent averaging length for the phase estimate.
      65536 samples = 65 ms at 1 Msps, comparable to what
      twinrx_lo_check.py integrates. The old 4096 averaged 24x
      less and made the GUI look far noisier than the CLI for
      the same signal.
    value: '65536'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    comment: |-
      Moving this slider triggers a full coherent
      retune (timed, twice) via the watcher thread.
    gui_hint: tabs@0:0,0,1,1
    label: Center Freq (Hz)
    orient: Qt.Horizontal
    start: 10e6
    step: 1e6
    stop: 6e9
    value: 2.4e9
  states: {}
- name: cmd_lead
  id: variable
  parameters:
    comment: |-
      How far ahead of "now" the timed tune is scheduled.
      Must exceed the host->FPGA latency. 0.1 s is safe.
    value: '0.1'
  states: {}
- name: dsp_manual
  id: variable
  parameters:
    comment: |-
      True  -> force every DDC to 0 Hz so the digital
      down-conversion adds no per-channel phase.
      Set False if you need exact requested centre freq.
    value: 'True'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: TwinRX gain range is 0 .. 93 dB.
    gui_hint: tabs@0:1,0,1,1
    label: RX Gain (dB)
    min_len: '100'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '93'
    value: '60'
  states: {}
- name: lo_export_chan
  id: variable
  parameters:
    comment: |-
      Channel whose synthesiser feeds everything else.
      0 = DB-A ch0 exports (cables A->B)  -- NOT WORKING on this unit
      2 = DB-B ch0 exports (cables B->A)  -- verified working
    value: '2'
  states: {}
- name: lo_sources
  id: variable
  parameters:
    comment: |-
      Per-channel LO source, index = UHD channel.
      Master board : exporter = internal (or reimport), partner = companion
      Slave  board : BOTH channels = external
      Valid: internal / companion / external / reimport / disabled
      Rx B exports here, not Rx A. Measured on this unit the jumpers
      carrying A LO-out to B LO-in pass nothing, while B to A works.
      Swap back to [internal, companion, external, external] with
      lo_export_chan 0 if those cables get repaired.
    value: '[''external'', ''external'', ''internal'', ''companion'']'
  states: {}
- name: ref_offset
  id: variable
  parameters:
    comment: |-
      An off-tone frequency inside the same passband.
      Comparing tone power against power here is what tells a real
      signal from LO leakage or crosstalk. A channel reading ~0 dB
      on this ratio is NOT receiving, however steady its phase.
    value: tone_offset + 53e3
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Per-channel rate. 1 Msps x 4ch is easy on 10GbE
      and plenty for a phase-coherence check.
    value: '1000000'
  states: {}
- name: subdev
  id: variable
  parameters:
    comment: |-
      DB-A = TwinRX #1 (ch0, ch1)
      DB-B = TwinRX #2 (ch2, ch3)
    value: '"A:0 A:1 B:0 B:1"'
  states: {}
- name: time_interp
  id: variable
  parameters:
    comment: Interpolation factor for time domain block
    value: '20'
  states: {}
- name: time_srate
  id: variable
  parameters:
    comment: Sampling rate specifically for time domain block (20 Msps)
    value: samp_rate * time_interp
  states: {}
- name: tone_bw
  id: variable
  parameters:
    comment: |-
      Half-width of the band kept around the tone, Hz.
      Narrow enough to reject DC and most of the noise, wide
      enough to tolerate the B210/X310 reference offset, which
      measured ~3.9 kHz at 2.4 GHz. 10 kHz halves the noise
      power the phase estimator sees versus the old 25 kHz.
    value: 10e3
  states: {}
- name: tone_offset
  id: variable
  parameters:
    comment: |-
      Baseband offset of the calibration tone, Hz.
      MUST match b210_tone_source.py --offset (default +200 kHz).
      Set 0 only if your source really is at the centre frequency,
      which makes it indistinguishable from LO leakage.
    value: 200e3
  states: {}
- name: tone_taps
  id: variable
  parameters:
    comment: Low-pass prototype for the translating filter.
    value: firdes.low_pass(1.0, samp_rate, tone_bw, tone_bw/2.0, firdes.WIN_HAMMING)
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    comment: B210 TX gain range is 0 .. 60 dB. Safe ceiling 60 dB.
    gui_hint: tabs@0:1,1,1,1
    label: TX Gain (dB)
    min_len: '100'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '50'
  states: {state: disabled}
- name: view_decim
  id: variable
  parameters:
    comment: Decimation before the GUI sinks.
    value: '2048'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.02'
    freq: tone_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: arg_10
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: arg_20
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: arg_30
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: avg_10
  id: blocks_moving_average_xx
  parameters:
    length: avg_len
    max_iter: '262144'
    scale: 1.0/avg_len
    type: complex
  states: {state: disabled}
- name: avg_20
  id: blocks_moving_average_xx
  parameters:
    length: avg_len
    max_iter: '262144'
    scale: 1.0/avg_len
    type: complex
  states: {state: disabled}
- name: avg_30
  id: blocks_moving_average_xx
  parameters:
    length: avg_len
    max_iter: '262144'
    scale: 1.0/avg_len
    type: complex
  states: {state: disabled}
- name: bpf_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tone_offset
    comment: |-
      Shift the tone to DC and throw away everything else --
      crucially the real DC term, which carries LO self-mixing
      leakage and would otherwise dominate the phase estimate.
    decim: '1'
    samp_rate: samp_rate
    taps: tone_taps
    type: ccc
  states: {state: disabled}
- name: bpf_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tone_offset
    comment: |-
      Shift the tone to DC and throw away everything else --
      crucially the real DC term, which carries LO self-mixing
      leakage and would otherwise dominate the phase estimate.
    decim: '1'
    samp_rate: samp_rate
    taps: tone_taps
    type: ccc
  states: {state: disabled}
- name: bpf_2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tone_offset
    comment: |-
      Shift the tone to DC and throw away everything else --
      crucially the real DC term, which carries LO self-mixing
      leakage and would otherwise dominate the phase estimate.
    decim: '1'
    samp_rate: samp_rate
    taps: tone_taps
    type: ccc
  states: {state: disabled}
- name: bpf_3
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tone_offset
    comment: |-
      Shift the tone to DC and throw away everything else --
      crucially the real DC term, which carries LO self-mixing
      leakage and would otherwise dominate the phase estimate.
    decim: '1'
    samp_rate: samp_rate
    taps: tone_taps
    type: ccc
  states: {state: disabled}
- name: dec_10
  id: blocks_keep_one_in_n
  parameters:
    n: view_decim
    type: complex
  states: {state: disabled}
- name: dec_20
  id: blocks_keep_one_in_n
  parameters:
    n: view_decim
    type: complex
  states: {state: disabled}
- name: dec_30
  id: blocks_keep_one_in_n
  parameters:
    n: view_decim
    type: complex
  states: {state: disabled}
- name: deg_10
  id: blocks_multiply_const_vxx
  parameters:
    comment: rad -> deg
    const: '57.29577951308232'
    type: float
  states: {state: disabled}
- name: deg_20
  id: blocks_multiply_const_vxx
  parameters:
    comment: rad -> deg
    const: '57.29577951308232'
    type: float
  states: {state: disabled}
- name: deg_30
  id: blocks_multiply_const_vxx
  parameters:
    comment: rad -> deg
    const: '57.29577951308232'
    type: float
  states: {state: disabled}
- name: mag_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: |-
      Power in the band-pass output = how much CW tone
      is actually arriving on this channel.
  states: {state: disabled}
- name: mag_1
  id: blocks_complex_to_mag_squared
  parameters:
    comment: |-
      Power in the band-pass output = how much CW tone
      is actually arriving on this channel.
  states: {state: disabled}
- name: mag_2
  id: blocks_complex_to_mag_squared
  parameters:
    comment: |-
      Power in the band-pass output = how much CW tone
      is actually arriving on this channel.
  states: {state: disabled}
- name: mag_3
  id: blocks_complex_to_mag_squared
  parameters:
    comment: |-
      Power in the band-pass output = how much CW tone
      is actually arriving on this channel.
  states: {state: disabled}
- name: magavg_0
  id: blocks_moving_average_xx
  parameters:
    length: avg_len
    max_iter: '262144'
    scale: 1.0/avg_len
    type: float
  states: {state: disabled}
- name: magavg_1
  id: blocks_moving_average_xx
  parameters:
    length: avg_len
    max_iter: '262144'
    scale: 1.0/avg_len
    type: float
  states: {state: disabled}
- name: magavg_2
  id: blocks_moving_average_xx
  parameters:
    length: avg_len
    max_iter: '262144'
    scale: 1.0/avg_len
    type: float
  states: {state: disabled}
- name: magavg_3
  id: blocks_moving_average_xx
  parameters:
    length: avg_len
    max_iter: '262144'
    scale: 1.0/avg_len
    type: float
  states: {state: disabled}
- name: magdb_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {state: disabled}
- name: magdb_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {state: disabled}
- name: magdb_2
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {state: disabled}
- name: magdb_3
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {state: disabled}
- name: magdec_0
  id: blocks_keep_one_in_n
  parameters:
    n: view_decim
    type: float
  states: {state: disabled}
- name: magdec_1
  id: blocks_keep_one_in_n
  parameters:
    n: view_decim
    type: float
  states: {state: disabled}
- name: magdec_2
  id: blocks_keep_one_in_n
  parameters:
    n: view_decim
    type: float
  states: {state: disabled}
- name: magdec_3
  id: blocks_keep_one_in_n
  parameters:
    n: view_decim
    type: float
  states: {state: disabled}
- name: mc_10
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: ch1 * conj(ch0)
  states: {state: disabled}
- name: mc_20
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: ch2 * conj(ch0)
  states: {state: disabled}
- name: mc_30
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: ch3 * conj(ch0)
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: |-
      All four traces should sit on top of each other
      in amplitude.  A channel 40-50 dB down usually means
      its LO never locked / the LO cable is missing.
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: tabs@1
    label1: ch0 (A:0)
    label2: ch1 (A:1)
    label3: ch2 (B:0)
    label4: ch3 (B:1)
    name: '"Per-channel spectrum (sanity / power balance)"'
    nconnections: '4'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '0.02'
    comment: |-
      These three numbers must be STABLE while you retune.
      Jumps in multiples of 90 deg = the known TwinRX
      external-LO ambiguity, see the notes file.
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tabs@0:4,0,1,2
    label1: ch1-ch0 deg
    label2: ch2-ch0 deg
    label3: ch3-ch0 deg
    max: '180'
    min: '-180'
    name: '"Steady-state phase offset"'
    nconnections: '3'
    type: float
    unit1: deg
    unit2: deg
    unit3: deg
  states: {state: disabled}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    comment: |-
      Tone power per channel, in the band-pass window only.
      If one channel sits far below the others, its RF cable
      is loose -- that exact fault cost hours once already.
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tabs@0:5,0,1,2
    label1: ch0 band
    label2: ch1 band
    label3: ch2 band
    label4: ch3 band
    max: '-40'
    min: '-120'
    name: '"Band power (dB) - this is mostly NOISE unless the meter above reads high"'
    nconnections: '4'
    type: float
    unit1: dB
    unit2: dB
    unit3: dB
    unit4: dB
  states: {state: disabled}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    comment: |-
      THE indicator to trust. Tone power minus off-tone power.
      Above ~6 dB the channel is really receiving. Near 0 dB it is
      NOT, no matter how steady its phase trace looks -- a channel
      with no signal can still track ch0 perfectly through internal
      crosstalk, which is coherent and therefore rock stable.
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tabs@0:2,0,1,2
    label1: ch0 RF A/RX1
    label2: ch1 RF A/RX2
    label3: ch2 RF B/RX1
    label4: ch3 RF B/RX2
    max: '50'
    min: '-10'
    name: '"IS THIS CHANNEL RECEIVING?  above 6 dB = YES.  near 0 dB = NO"'
    nconnections: '4'
    type: float
    unit1: dB
    unit2: dB
    unit3: dB
    unit4: dB
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      A flat, non-drifting line = LO is shared.
      A ramp = the channels are on independent synthesisers.
    grid: 'True'
    gui_hint: tabs@0:3,0,1,2
    label1: ch1 - ch0
    label2: ch2 - ch0
    label3: ch3 - ch0
    name: '"Relative phase vs ch0 (degrees)"'
    nconnections: '3'
    size: '512'
    srate: samp_rate/view_decim
    type: float
    ylabel: Phase (deg)
    ymax: '200'
    ymin: '-200'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: green
    color2: magenta
    color3: black
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: tabs@0:6,0,1,2
    label1: Ch2 RF B/RX1
    label2: Ch3 RF B/RX2
    label3: TX Signal (B210)
    name: '"ch2 / ch3 — DC removed, amplitude locked to 0.1 (phase free to drift)"'
    nconnections: '3'
    size: '1000'
    srate: time_srate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    width1: '2'
    width2: '2'
    width3: '2'
    ymax: '0.05'
    ymin: '-0.05'
  states: {}
- name: ratio_0
  id: blocks_sub_xx
  parameters:
    comment: tone dB minus reference dB
    type: float
  states: {state: disabled}
- name: ratio_1
  id: blocks_sub_xx
  parameters:
    comment: tone dB minus reference dB
    type: float
  states: {state: disabled}
- name: ratio_2
  id: blocks_sub_xx
  parameters:
    comment: tone dB minus reference dB
    type: float
  states: {state: disabled}
- name: ratio_3
  id: blocks_sub_xx
  parameters:
    comment: tone dB minus reference dB
    type: float
  states: {state: disabled}
- name: rbpf_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ref_offset
    comment: Same filter, parked off the tone, as a noise reference.
    decim: '1'
    samp_rate: samp_rate
    taps: tone_taps
    type: ccc
  states: {state: disabled}
- name: rbpf_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ref_offset
    comment: Same filter, parked off the tone, as a noise reference.
    decim: '1'
    samp_rate: samp_rate
    taps: tone_taps
    type: ccc
  states: {state: disabled}
- name: rbpf_2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ref_offset
    comment: Same filter, parked off the tone, as a noise reference.
    decim: '1'
    samp_rate: samp_rate
    taps: tone_taps
    type: ccc
  states: {state: disabled}
- name: rbpf_3
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ref_offset
    comment: Same filter, parked off the tone, as a noise reference.
    decim: '1'
    samp_rate: samp_rate
    taps: tone_taps
    type: ccc
  states: {state: disabled}
- name: rdec_0
  id: blocks_keep_one_in_n
  parameters:
    n: view_decim
    type: float
  states: {state: disabled}
- name: rdec_1
  id: blocks_keep_one_in_n
  parameters:
    n: view_decim
    type: float
  states: {state: disabled}
- name: rdec_2
  id: blocks_keep_one_in_n
  parameters:
    n: view_decim
    type: float
  states: {state: disabled}
- name: rdec_3
  id: blocks_keep_one_in_n
  parameters:
    n: view_decim
    type: float
  states: {state: disabled}
- name: rmag_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: rmag_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: rmag_2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: rmag_3
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: rmagavg_0
  id: blocks_moving_average_xx
  parameters:
    length: avg_len
    max_iter: '262144'
    scale: 1.0/avg_len
    type: float
  states: {state: disabled}
- name: rmagavg_1
  id: blocks_moving_average_xx
  parameters:
    length: avg_len
    max_iter: '262144'
    scale: 1.0/avg_len
    type: float
  states: {state: disabled}
- name: rmagavg_2
  id: blocks_moving_average_xx
  parameters:
    length: avg_len
    max_iter: '262144'
    scale: 1.0/avg_len
    type: float
  states: {state: disabled}
- name: rmagavg_3
  id: blocks_moving_average_xx
  parameters:
    length: avg_len
    max_iter: '262144'
    scale: 1.0/avg_len
    type: float
  states: {state: disabled}
- name: rmagdb_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {state: disabled}
- name: rmagdb_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {state: disabled}
- name: rmagdb_2
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {state: disabled}
- name: rmagdb_3
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {state: disabled}
- name: snippet_lo_config
  id: snippet
  parameters:
    code: |
      # =================================================================
      # TwinRX / USRP-2945  --  LO ROUTING + COHERENT TIMED TUNE
      # Runs AFTER the blocks are built, BEFORE the flowgraph starts.
      # =================================================================
      import time
      from gnuradio import uhd as _uhd

      _u = self.uhd_usrp_source_0
      _nch = 4
      _lo_src = list(self.lo_sources)
      _exp_ch = int(self.lo_export_chan)

      print('')
      print('=== TwinRX LO configuration =====================================')
      print('  subdev spec      : %s' % _u.get_subdev_spec(0))
      print('  LO names         : %s' % list(_u.get_lo_names(0)))
      print('  LO sources avail : %s' % list(_u.get_lo_sources(_uhd.ALL_LOS, 0)))

      # --- Step 1: drop every export first.  UHD refuses a state where two
      #             channels export at once, so clear before we re-assert.
      for _ch in range(_nch):
          _u.set_lo_export_enabled(False, _uhd.ALL_LOS, _ch)

      # --- Step 2: program the source of every channel.
      #     'internal'  : this channel's own synth drives it
      #     'companion' : takes the other channel's synth, same daughterboard
      #     'external'  : takes the LO IN connectors (J4=LO1, J2=LO2)
      #     'reimport'  : own synth, exported AND looped back in through LO IN
      #                   (use when a splitter feeds the master's own LO IN,
      #                    so both boards see identical cable delay)
      for _ch in range(_nch):
          _u.set_lo_source(_lo_src[_ch], _uhd.ALL_LOS, _ch)

      # --- Step 3: exactly one exporter.  Never 'external' + export.
      _u.set_lo_export_enabled(True, _uhd.ALL_LOS, _exp_ch)

      for _ch in range(_nch):
          print('  ch%d  requested=%-10s readback=%-10s export=%s'
                % (_ch, _lo_src[_ch],
                   _u.get_lo_source(_uhd.ALL_LOS, _ch),
                   _u.get_lo_export_enabled(_uhd.ALL_LOS, _ch)))

      # --- Hardware DC-offset correction, as gr-doa's
      #     twinrx_usrp_source.py does on every channel.
      for _ch in range(_nch):
          _u.set_auto_dc_offset(True, _ch)

      # --- Step 4: a known device time so timed commands mean something.
      _u.set_time_now(_uhd.time_spec(0.0), 0)


      def _twinrx_tune(freq):
          """Tune all channels on the SAME clock edge.

          Why twice:  a cold TwinRX tune needs more SPI transactions than
          the X310 command FIFO (16 deep) can hold, so part of the first
          burst executes untimed.  The driver caches band/filter/synth
          state, so the second, identical burst is short enough to fit and
          lands atomically on all four channels.
          """
          _tr = _uhd.tune_request(float(freq))
          if bool(self.dsp_manual):
              # Pin every DDC to 0 Hz -> the digital stage contributes no
              # per-channel phase, only the shared LO does.
              _tr.rf_freq_policy  = _uhd.tune_request.POLICY_AUTO
              _tr.dsp_freq_policy = _uhd.tune_request.POLICY_MANUAL
              _tr.dsp_freq        = 0.0
          _lead = float(self.cmd_lead)
          for _pass in range(2):
              _u.set_command_time(_u.get_time_now(0) + _uhd.time_spec(_lead), 0)
              for _ch in range(_nch):
                  _u.set_center_freq(_tr, _ch)
              _u.clear_command_time(0)
              time.sleep(_lead + 0.05)
          print('  tuned -> %.6f MHz   (ch0 actual %.6f MHz)'
                % (float(freq) / 1e6, _u.get_center_freq(0) / 1e6))


      self.twinrx_tune = _twinrx_tune
      self.twinrx_tune(float(self.center_freq))
      import subprocess, os
      if subprocess.run(['pgrep', '-f', 'b210_tone_source.py'], stdout=subprocess.DEVNULL).returncode != 0:
          print('[*] Starting B210 calibration source in background...')
          _b210_env = dict(os.environ)
          _b210_env.pop('UHD315_DIR', None)
          _b210_env.pop('GR38_DIR', None)
          _b210_env['PATH'] = '/usr/local/sbin:/usr/local/bin:/usr/sbin:/usr/bin:/sbin:/bin'
          self._b210_proc = subprocess.Popen(['python3', '-u', '/home/shankar/radar2/b210_tone_source.py', '--freq', str(self.center_freq), '--gain', '55', '--pad', '30'], env=_b210_env, stdout=subprocess.DEVNULL, stderr=subprocess.DEVNULL)
          time.sleep(3)
      print('=================================================================')
      print('')
    section: main_after_init
  states: {}
- name: snippet_lo_stop
  id: snippet
  parameters:
    code: |
      self._twinrx_run = False
      if hasattr(self, '_b210_proc') and self._b210_proc:
          try:
              self._b210_proc.terminate()
          except Exception:
              pass
      print('LO watcher stopped.')
    section: main_after_stop
  states: {}
- name: snippet_lo_watch
  id: snippet
  parameters:
    code: |
      # Watch the Center Freq slider and redo the FULL coherent tune
      # sequence whenever it moves.  A plain GRC callback would call
      # set_center_freq() per channel, untimed, and break coherence.
      import time
      import threading

      self._twinrx_run = True


      def _twinrx_watch():
          _last = float(self.center_freq)
          while self._twinrx_run:
              _f = float(self.center_freq)
              if _f != _last:
                  _last = _f
                  try:
                      self.twinrx_tune(_f)
                  except Exception as _e:
                      print('coherent retune failed: %s' % _e)
              time.sleep(0.2)


      self._twinrx_thread = threading.Thread(target=_twinrx_watch)
      self._twinrx_thread.daemon = True
      self._twinrx_thread.start()
      print('LO watcher running - move the Center Freq slider to retune coherently.')
    section: main_after_start
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Control & Phase
    label1: Spectra
    num_tabs: '2'
  states: {}
- name: time_resamp_2
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: time_interp
    taps: '[t * (-0.470642-0.882324j) for t in firdes.low_pass(time_interp, time_srate, 300e3, 50e3, firdes.WIN_HAMMING)]'
    type: ccc
  states: {}
- name: time_resamp_3
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: time_interp
    taps: '[t * (0.691236+0.722629j) for t in firdes.low_pass(time_interp, time_srate, 300e3, 50e3, firdes.WIN_HAMMING)]'
    type: ccc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: center_freq
    dev_addr: '"type=b200"'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sd_spec0: '"A:A"'
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX1
    ant1: RX2
    ant2: RX1
    ant3: RX2
    center_freq0: center_freq
    center_freq1: center_freq
    center_freq2: center_freq
    center_freq3: center_freq
    clock_rate: 200e6
    clock_source0: internal
    comment: |-
      TwinRX REQUIRES master_clock_rate = 200 MHz.
      LO controls are deliberately hidden here: GRC would emit
      set_lo_source() AFTER set_center_freq(), which is the wrong
      order.  The Python Snippet does it properly instead.
    dc_offs_enb0: ''
    dc_offs_enb1: ''
    dc_offs_enb2: ''
    dc_offs_enb3: ''
    dev_addr: '"type=x300"'
    dev_args: '""'
    gain0: gain
    gain1: gain
    gain2: gain
    gain3: gain
    iq_imbal_enb0: ''
    iq_imbal_enb1: ''
    iq_imbal_enb2: ''
    iq_imbal_enb3: ''
    nchan: '4'
    norm_gain0: 'False'
    norm_gain1: 'False'
    norm_gain2: 'False'
    norm_gain3: 'False'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sd_spec0: subdev
    sync: none
    time_source0: internal
    type: fc32
  states: {}
- name: time_resamp_tx
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: time_interp
    taps: firdes.low_pass(time_interp * 10, time_srate, 300e3, 50e3, firdes.WIN_HAMMING)
    type: ccc
  states: {}
- name: c2r_2
  id: blocks_complex_to_real
  parameters:
    comment: Extract real part of Ch2 for time plot
  states: {}
- name: c2r_3
  id: blocks_complex_to_real
  parameters:
    comment: Extract real part of Ch3 for time plot
  states: {}
- name: c2r_tx
  id: blocks_complex_to_real
  parameters:
    comment: Extract real part of TX signal for time plot
  states: {}
- name: dcblock_2
  id: dc_blocker_xx
  parameters:
    comment: Strip residual DC / LO leakage.
    length: '1024'
    long_form: 'True'
    type: cc
  states: {}
- name: agc_2
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.5'
    decay_rate: '0.5'
    comment: Hold a constant amplitude over time.
    gain: '100.0'
    max_gain: 1e6
    reference: '0.1'
    type: complex
  states: {}
- name: dcblock_3
  id: dc_blocker_xx
  parameters:
    comment: Strip residual DC / LO leakage.
    length: '1024'
    long_form: 'True'
    type: cc
  states: {}
- name: agc_3
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.5'
    decay_rate: '0.5'
    comment: Hold a constant amplitude over time.
    gain: '100.0'
    max_gain: 1e6
    reference: '0.1'
    type: complex
  states: {}
- name: disp_bw
  id: variable
  parameters:
    comment: |-
      Display band around tone_offset.
      MUST be wide enough to cover the B210<->X310 clock offset:
      they are NOT frequency-locked, so the tone lands a few kHz
      off the nominal tone_offset (measured ~+3.9 kHz).
      Too narrow and the band-pass rejects the tone and you display
      pure noise (Rayleigh envelope, 52% ripple).
    value: 20e3
  states: {}
- name: disp_taps
  id: variable
  parameters:
    comment: Narrow prototype for the display path.
    value: firdes.low_pass(1.0, samp_rate, disp_bw, disp_bw/2.0, firdes.WIN_HAMMING)
  states: {}
- name: disp_taps_bp
  id: variable
  parameters:
    comment: Complex band-pass around the tone, tone stays in place.
    value: firdes.complex_band_pass(1.0, samp_rate, tone_offset - disp_bw/2, tone_offset + disp_bw/2, disp_bw/2, firdes.WIN_HAMMING)
  states: {}
- name: bp_2
  id: fir_filter_xxx
  parameters:
    comment: Keep only the tone; tone stays at its RF offset.
    decim: '1'
    taps: disp_taps_bp
    type: ccc
  states: {}
- name: bp_3
  id: fir_filter_xxx
  parameters:
    comment: Keep only the tone; tone stays at its RF offset.
    decim: '1'
    taps: disp_taps_bp
    type: ccc
  states: {}
- name: null_0
  id: blocks_null_sink
  parameters:
    comment: |-
      ch0 is not displayed here (ch0 = dead port, ch1 = weak).
      Terminate the stream so the source port stays connected.
    bus_structure_sink: ''
    type: complex
  states: {}
- name: null_1
  id: blocks_null_sink
  parameters:
    comment: |-
      ch1 is not displayed here (ch0 = dead port, ch1 = weak).
      Terminate the stream so the source port stays connected.
    bus_structure_sink: ''
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [arg_10, '0', deg_10, '0']
- [arg_20, '0', deg_20, '0']
- [arg_30, '0', deg_30, '0']
- [avg_10, '0', dec_10, '0']
- [avg_20, '0', dec_20, '0']
- [avg_30, '0', dec_30, '0']
- [bpf_0, '0', mag_0, '0']
- [bpf_0, '0', mc_10, '1']
- [bpf_0, '0', mc_20, '1']
- [bpf_0, '0', mc_30, '1']
- [bpf_1, '0', mag_1, '0']
- [bpf_1, '0', mc_10, '0']
- [bpf_2, '0', mag_2, '0']
- [bpf_2, '0', mc_20, '0']
- [bpf_3, '0', mag_3, '0']
- [bpf_3, '0', mc_30, '0']
- [dec_10, '0', arg_10, '0']
- [dec_20, '0', arg_20, '0']
- [dec_30, '0', arg_30, '0']
- [deg_10, '0', qtgui_number_sink_0, '0']
- [deg_10, '0', qtgui_time_sink_x_0, '0']
- [deg_20, '0', qtgui_number_sink_0, '1']
- [deg_20, '0', qtgui_time_sink_x_0, '1']
- [deg_30, '0', qtgui_number_sink_0, '2']
- [deg_30, '0', qtgui_time_sink_x_0, '2']
- [mag_0, '0', magavg_0, '0']
- [mag_1, '0', magavg_1, '0']
- [mag_2, '0', magavg_2, '0']
- [mag_3, '0', magavg_3, '0']
- [magavg_0, '0', magdb_0, '0']
- [magavg_1, '0', magdb_1, '0']
- [magavg_2, '0', magdb_2, '0']
- [magavg_3, '0', magdb_3, '0']
- [magdb_0, '0', magdec_0, '0']
- [magdb_0, '0', ratio_0, '0']
- [magdb_1, '0', magdec_1, '0']
- [magdb_1, '0', ratio_1, '0']
- [magdb_2, '0', magdec_2, '0']
- [magdb_2, '0', ratio_2, '0']
- [magdb_3, '0', magdec_3, '0']
- [magdb_3, '0', ratio_3, '0']
- [magdec_0, '0', qtgui_number_sink_1, '0']
- [magdec_1, '0', qtgui_number_sink_1, '1']
- [magdec_2, '0', qtgui_number_sink_1, '2']
- [magdec_3, '0', qtgui_number_sink_1, '3']
- [mc_10, '0', avg_10, '0']
- [mc_20, '0', avg_20, '0']
- [mc_30, '0', avg_30, '0']
- [ratio_0, '0', rdec_0, '0']
- [ratio_1, '0', rdec_1, '0']
- [ratio_2, '0', rdec_2, '0']
- [ratio_3, '0', rdec_3, '0']
- [rbpf_0, '0', rmag_0, '0']
- [rbpf_1, '0', rmag_1, '0']
- [rbpf_2, '0', rmag_2, '0']
- [rbpf_3, '0', rmag_3, '0']
- [rdec_0, '0', qtgui_number_sink_2, '0']
- [rdec_1, '0', qtgui_number_sink_2, '1']
- [rdec_2, '0', qtgui_number_sink_2, '2']
- [rdec_3, '0', qtgui_number_sink_2, '3']
- [rmag_0, '0', rmagavg_0, '0']
- [rmag_1, '0', rmagavg_1, '0']
- [rmag_2, '0', rmagavg_2, '0']
- [rmag_3, '0', rmagavg_3, '0']
- [rmagavg_0, '0', rmagdb_0, '0']
- [rmagavg_1, '0', rmagdb_1, '0']
- [rmagavg_2, '0', rmagdb_2, '0']
- [rmagavg_3, '0', rmagdb_3, '0']
- [rmagdb_0, '0', ratio_0, '1']
- [rmagdb_1, '0', ratio_1, '1']
- [rmagdb_2, '0', ratio_2, '1']
- [rmagdb_3, '0', ratio_3, '1']
- [uhd_usrp_source_0, '0', bpf_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', rbpf_0, '0']
- [uhd_usrp_source_0, '1', bpf_1, '0']
- [uhd_usrp_source_0, '1', qtgui_freq_sink_x_0, '1']
- [uhd_usrp_source_0, '1', rbpf_1, '0']
- [uhd_usrp_source_0, '2', bpf_2, '0']
- [uhd_usrp_source_0, '2', qtgui_freq_sink_x_0, '2']
- [uhd_usrp_source_0, '2', rbpf_2, '0']
- [uhd_usrp_source_0, '3', bpf_3, '0']
- [uhd_usrp_source_0, '3', qtgui_freq_sink_x_0, '3']
- [uhd_usrp_source_0, '3', rbpf_3, '0']
- [analog_sig_source_x_0, '0', time_resamp_tx, '0']
- [time_resamp_tx, '0', c2r_tx, '0']
- [uhd_usrp_source_0, '2', dcblock_2, '0']
- [uhd_usrp_source_0, '3', dcblock_3, '0']
- [dcblock_2, '0', bp_2, '0']
- [dcblock_3, '0', bp_3, '0']
- [bp_2, '0', agc_2, '0']
- [agc_2, '0', time_resamp_2, '0']
- [time_resamp_2, '0', c2r_2, '0']
- [bp_3, '0', agc_3, '0']
- [agc_3, '0', time_resamp_3, '0']
- [time_resamp_3, '0', c2r_3, '0']
- [c2r_2, '0', qtgui_time_sink_x_1, '0']
- [c2r_3, '0', qtgui_time_sink_x_1, '1']
- [c2r_tx, '0', qtgui_time_sink_x_1, '2']
- [uhd_usrp_source_0, '0', null_0, '0']
- [uhd_usrp_source_0, '1', null_1, '0']

metadata:
  file_format: 1
