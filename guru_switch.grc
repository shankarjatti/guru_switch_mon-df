options:
  parameters:
    author: shankar
    comment: |-
      USRP-2945 (X310 + 2x TwinRX) LO configuration and phase-coherence test.
      GNU Radio 3.8 / UHD 3.15.
      All four channels are driven from ONE synthesiser, tuned with timed commands.
    description: TwinRX LO sharing / phase coherence test bench
    generate_options: qt_gui
    id: guru_switch
    output_language: python
    title: 'Guru SWITCH: USRP-2945 DF (shared LO, 5 ms / 7 ms hopping) + MON (own LO per channel), switched on the radio clock'
  states: {}

blocks:
- name: avg_len
  id: variable
  parameters:
    comment: |-
      Coherent averaging length for the phase estimate.
      65536 samples = 65 ms at 1 Msps, comparable to what
      twinrx_lo_check.py integrates. The old 4096 averaged 24x
      less and made the GUI look far noisier than the CLI for
      the same signal.
    value: '65536'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: |-
      Reported by the hopping block, not a control any more.
      The band list lives in the TwinRX Hopping USRP Source block.
    value: tone_band
  states: {}
- name: cmd_lead
  id: variable
  parameters:
    comment: |-
      How far ahead of "now" the timed tune is scheduled.
      Must exceed the host->FPGA latency. 0.1 s is safe.
    value: '0.1'
  states: {}
- name: disp_bw
  id: variable
  parameters:
    comment: |-
      Wide enough to keep the tone when the transmitter's crystal is off
      frequency. The HackRF is ~+/-20 ppm, which is ~116 kHz at 5.8 GHz,
      so the old 20 kHz window would have rejected it entirely.
    value: 300e3
  states: {}
- name: disp_gain
  id: variable
  parameters:
    comment: |-
      Fixed display gain for ch2/ch3.
      Replaces the AGC: the tone is already steady to ~0.6%, so no
      automatic gain is needed.  A fixed gain keeps the true relative
      amplitude between channels and has no start-up transient.
    value: '25'
  states: {}
- name: disp_interp_trans
  id: variable
  parameters:
    comment: |-
      Transition width of the display interpolator's anti-imaging filter.

      time_resamp_N interpolates 1 Msps up to time_srate purely so the time
      plot draws a smooth waveform. The filter only has to reject the images
      of the interpolated stream: the signal reaches disp_bw, the first image
      starts at samp_rate - disp_bw, so everything between the two is
      transition band and nothing is gained by making it narrower.

      It was fixed at 50 kHz, eight times tighter than that. Hamming taps go
      as 3.3 * fs / transition, so 50 kHz meant ~1320 taps running at 20 Msps
      on four channels -- 5.3 GMAC/s, measured as 527% CPU and a load average
      of 16 on a 12 core host, for a picture. A starved host is what makes
      the X310's RFNoC control acks time out, which is what kills the stream.
    value: samp_rate - 2 * disp_bw
  states: {}
- name: disp_taps_bp
  id: variable
  parameters:
    comment: |-
      One-sided: the tone always arrives on the positive side.
      Bands whose receive chain inverts the spectrum are pre-compensated at
      the transmitter -- 5.1 GHz is sent a -200 kHz tone so it still lands at
      +200 kHz (see --offset-map). Widening the filter to cover both sides
      would work too, but costs 3 dB of noise bandwidth to paper over
      something better fixed at the source.
    value: firdes.complex_band_pass(1.0, samp_rate, tone_offset - disp_bw/2, tone_offset + disp_bw/2, disp_bw/4, firdes.WIN_HAMMING)
  states: {}
- name: dsp_manual
  id: variable
  parameters:
    comment: |-
      True  -> force every DDC to 0 Hz so the digital
      down-conversion adds no per-channel phase.
      Set False if you need exact requested centre freq.
    value: 'True'
  states: {}
- name: lo_export_chan
  id: variable
  parameters:
    comment: |-
      Channel whose synthesiser feeds everything else.
      0 = DB-A ch0 exports (cables A->B)  -- NOT WORKING on this unit
      2 = DB-B ch0 exports (cables B->A)  -- verified working
    value: '2'
  states: {}
- name: lo_sources
  id: variable
  parameters:
    comment: |-
      Per-channel LO source, index = UHD channel.
      Master board : exporter = internal (or reimport), partner = companion
      Slave  board : BOTH channels = external
      Valid: internal / companion / external / reimport / disabled
      Rx B exports here, not Rx A. Measured on this unit the jumpers
      carrying A LO-out to B LO-in pass nothing, while B to A works.
      Swap back to [internal, companion, external, external] with
      lo_export_chan 0 if those cables get repaired.
    value: '[''external'', ''external'', ''internal'', ''companion'']'
  states: {}
- name: ph_avg
  id: variable
  parameters:
    comment: Averaging length for the displayed phase.
    value: '16384'
  states: {}
- name: ph_skip
  id: variable
  parameters:
    comment: |-
      Samples skipped before measuring, so the reading is
      past the start-up transient.
    value: 2**13
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Per-channel rate. 1 Msps x 4ch is easy on 10GbE
      and plenty for a phase-coherence check.
    value: '2000000'
  states: {}
- name: stream_state
  id: variable_qtgui_label
  parameters:
    comment: |-
      Says on screen whether the radio is actually sending.
      When the stream dies the traces hold their last value,
      which looks like a steady reading rather than no reading.
      The snippet below drives this from the block's watchdog.
    gui_hint: tabs@0:3,0,1,3
    label: STREAM
    type: string
    value: '''receiving'''
  states: {}
- name: subdev
  id: variable
  parameters:
    comment: |-
      DB-A = TwinRX #1 (ch0, ch1)
      DB-B = TwinRX #2 (ch2, ch3)
    value: '"A:0 A:1 B:0 B:1"'
  states: {}
- name: time_interp
  id: variable
  parameters:
    comment: Interpolation factor for time domain block
    value: '20'
  states: {}
- name: time_srate
  id: variable
  parameters:
    comment: Sampling rate specifically for time domain block (20 Msps)
    value: samp_rate * time_interp
  states: {}
- name: tone_bw
  id: variable
  parameters:
    comment: |-
      Half-width of the band kept around the tone, Hz.
      Narrow enough to reject DC and most of the noise, wide
      enough to tolerate the B210/X310 reference offset, which
      measured ~3.9 kHz at 2.4 GHz. 10 kHz halves the noise
      power the phase estimator sees versus the old 25 kHz.
    value: 10e3
  states: {}
- name: tone_offset
  id: variable
  parameters:
    comment: |-
      Baseband offset of the calibration tone, Hz.
      MUST match b210_tone_source.py --offset (default +200 kHz).
      Set 0 only if your source really is at the centre frequency,
      which makes it indistinguishable from LO leakage.
    value: 200e3
  states: {}
- name: tone_taps
  id: variable
  parameters:
    comment: Low-pass prototype for the translating filter.
    value: firdes.low_pass(1.0, samp_rate, tone_bw, tone_bw/2.0, firdes.WIN_HAMMING)
  states: {}
- name: tx_control
  id: variable
  parameters:
    comment: |-
      hackrf_tone_source.py control socket. The transmitter is told to
      retune first, so it is already there when we arrive.
      Set to '' to leave the transmitter alone.
    value: '''127.0.0.1:5123'''
  states: {}
- name: tx_disp_gain
  id: variable
  parameters:
    comment: |-
      Display-only gain for the black TX reference trace.
      The B210 TX sink in this flowgraph is DISABLED -- the real
      transmitter is b210_tone_source.py -- so this scales the
      on-screen trace only and cannot change radiated power.
    value: '10'
  states: {}
- name: view_decim
  id: variable
  parameters:
    comment: Decimation before the GUI sinks.
    value: '2048'
  states: {}
- name: bp_0
  id: fir_filter_xxx
  parameters:
    comment: Keep only the tone.
    decim: '1'
    taps: disp_taps_bp
    type: ccc
  states: {}
- name: bp_1
  id: fir_filter_xxx
  parameters:
    comment: Keep only the tone.
    decim: '1'
    taps: disp_taps_bp
    type: ccc
  states: {}
- name: bp_2
  id: fir_filter_xxx
  parameters:
    comment: Keep only the tone.
    decim: '1'
    taps: disp_taps_bp
    type: ccc
  states: {}
- name: bp_3
  id: fir_filter_xxx
  parameters:
    comment: Keep only the tone.
    decim: '1'
    taps: disp_taps_bp
    type: ccc
  states: {}
- name: phase_correct_hopping_0
  id: phase_correct_hopping
  parameters:
    cal_file: '""'
    comment: |-
      Removes the fixed inter-channel offset, per band. Measured 2026-09-24 through this same radio configuration -- gains 46/60/69 and gain_trim (0, -13.3, 1.5, -1.7) -- because RX gain shifts phase here, so a table measured any other way does not apply. Verified: residuals -0.05..+0.23 deg on all three bands, against a measurement noise floor of 0.2-0.3 deg.
      VALID FOR THIS POWER SESSION ONLY. The LO dividers relock to a new phase every time the X310 is power cycled; re-run phase_table_measure.py after one, or these numbers silently correct to the wrong place.
    deg_0: (175.90, -86.62, -168.03)
    deg_1: (111.43, 71.93, 35.91)
    deg_2: (82.66, 155.54, 173.74)
    deg_3: (0.0, 0.0, 0.0)
    dwell_0: '10'
    dwell_1: '10'
    dwell_2: '10'
    dwell_3: '10'
    follow_source: 'True'
    freq_0: '2400000000.0'
    freq_1: '5200000000.0'
    freq_2: '5800000000.0'
    freq_3: '2400000000'
    freq_tol: '1000000'
    num_bands: '3'
    num_channels: '4'
    settle: '1.0'
    start_delay: '2.0'
    follow_tags: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: |-
      Wideband view of what each channel actually receives: the tone,
      any LO leakage left after the DC blocker, and the noise floor.
      Taken before the display band-pass, so it shows the whole
      1 MHz span rather than just the tone.
    fc: center_freq
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: tabs@1:0,0,1,2
    label1: Ch0 RF A/RX1
    label2: Ch1 RF A/RX2
    label3: Ch2 RF B/RX1 (LO master)
    label4: Ch3 RF B/RX2
    name: '"Spectrum - all 4 channels (DC removed)"'
    nconnections: '4'
    type: complex
    width1: '2'
    width2: '2'
    width3: '2'
    width4: '2'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-20'
  states: {}
- name: snippet_hop
  id: snippet
  parameters:
    code: |
      # Radio-clock hopping: the band changes every slot on the radio's own clock,
      # far faster than a GUI can follow, so nothing here touches the band. The
      # correction, the plot and the readouts all switch on the hop marks the
      # source puts on the exact samples. This only reports status, twice a second.
      from PyQt5 import QtCore

      self._hop_run = True
      self._fast_state = {}

      def _poll():
          st = self._fast_state
          src = self.twinrx_radio_source_0
          try:
              s = src.get_schedule_stats()
              alive = src.stream_is_alive()
              stalls = src.get_stream_stalls()
          except Exception as e:
              s, alive, stalls = None, None, 0
              if not st.get('err'):
                  st['err'] = True
                  print('[follow] cannot read the source: %s: %s' % (type(e).__name__, e))
          if s is not None:
              txt = ('slots %d | used %d | late %d | unlocked %d | skipped %d | too slow %d | '
                     'send: typical %.1f ms, worst %.1f ms (limit 5.5 ms)'
                     % (s['slots'], s['valid'], s['late'], s['unlocked'], s['skipped'],
                        s['unknown_in_time'], s.get('avg_send_ms', 0.0), s['max_send_ms']))
              if s['timing_lost']:
                  txt = 'TIMING LOST - restart. ' + txt
              if txt != st.get('sched'):
                  st['sched'] = txt
                  self.set_sched_state(txt)
          state = ('receiving' if alive else
                   'UNKNOWN - cannot read the stream state' if alive is None else
                   'STOPPED - the radio is not sending, nothing below is a reading')
          if stalls:
              state += '   (recovered %d time(s) this run)' % stalls
          if state != st.get('stream'):
              st['stream'] = state
              self.set_stream_state(state)

      # CALIBRATE: re-measure the table on the live chain (lab tone), see
      # doa/hop_calibrator.py. Result is applied only if every band passes.
      import os
      import time
      import doa
      from PyQt5 import Qt as _Qt
      self._cal = doa.hop_calibrator(
          self.twinrx_radio_source_0, self.phase_correct_hopping_0, {2400000000.0: self.met_0, 5200000000.0: self.met_1, 5800000000.0: self.met_2},
          [2400000000.0, 5200000000.0, 5800000000.0], secs=4.0,
          out_file=os.path.join(os.path.dirname(os.path.abspath(__file__)), 'phase_table_live_deg.txt'))
      self._cal_btn = _Qt.QPushButton('CALIBRATE  (lab tone on each band, ~15 s)')
      self._cal_lbl = _Qt.QLabel('CAL: startup table from the flowgraph (not re-measured this session)')
      def _cal_click():
          if self._cal.start(restore_freq=self.tone_band):
              self._cal_btn.setEnabled(False)
      self._cal_btn.clicked.connect(_cal_click)
      self.tabs_grid_layout_0.addWidget(self._cal_btn, 0, 0, 1, 1)
      self.tabs_grid_layout_0.addWidget(self._cal_lbl, 0, 1, 1, 2)

      # one status line per band: SIGNAL or FLAT, from that band's own dwells
      self._band_lbl = []
      for _i, (_f, _m) in enumerate([(2400000000.0, self.met_0), (5200000000.0, self.met_1), (5800000000.0, self.met_2)]):
          _l = _Qt.QLabel('%g GHz: waiting for dwells' % (_f / 1e9))
          _l.setStyleSheet('font-family: monospace; font-size: 13pt;')
          self.tabs_grid_layout_2.addWidget(_l, 1 + _i, 0, 1, 3)
          self._band_lbl.append((_f, _m, _l, {'w': 0, 't': 0}))

      self._now_lbl = _Qt.QLabel('RECEIVING NOW: starting')
      self._now_lbl.setStyleSheet('font-size: 15pt; font-weight: bold;')
      self.tabs_grid_layout_0.addWidget(self._now_lbl, 4, 0, 1, 3)
      self._lock_lbl = _Qt.QLabel('LO LOCK: starting')
      self._lock_lbl.setStyleSheet('font-size: 12pt;')
      self.tabs_grid_layout_0.addWidget(self._lock_lbl, 5, 0, 1, 3)
      self._show_lbl = _Qt.QLabel('SHOWING: starting')
      self._show_lbl.setStyleSheet('font-size: 13pt; font-weight: bold; color: #1a4d8f;')
      self.tabs_grid_layout_0.addWidget(self._show_lbl, 6, 0, 1, 3)

      def _lock_poll():
          bs = self.twinrx_radio_source_0.get_band_lock_stats()
          parts = []
          for _f in [2400000000.0, 5200000000.0, 5800000000.0]:
              b = [v for k, v in bs.items() if abs(k - _f) <= 1e6]
              if not b:
                  parts.append('%g GHz: waiting' % (_f / 1e9))
                  continue
              b = b[0]
              why = [('%d not locked' % b['unlocked']) if b['unlocked'] else '',
                     ('%d late' % b['late']) if b['late'] else '',
                     ('%d skipped' % b['skipped']) if b['skipped'] else '',
                     ('%d no burst' % b.get('no burst', 0)) if b.get('no burst', 0) else '']
              why = ', '.join(w for w in why if w)
              parts.append('%g GHz: used %d/%d%s' % (_f / 1e9, b['locked'], b['slots'],
                           '' if not why else '  (not used: %s)' % why))
          self._lock_lbl.setText('DWELLS (LO lock confirmed before every one):   ' + '   |   '.join(parts))
          tb = float(self.tone_band)
          b = [v for k, v in bs.items() if abs(k - tb) <= 1e6]
          # say exactly why a dwell was not used: the LO itself, or the PC's timing
          if not b or b[0]['slots'] == 0:
              lock_txt = 'waiting for dwells'
          elif b[0]['unlocked']:
              lock_txt = 'LO NOT LOCKED on %d dwells (those are not drawn)' % b[0]['unlocked']
          elif b[0]['locked'] == b[0]['slots']:
              lock_txt = 'LO LOCKED on every dwell'
          else:
              lock_txt = ('LO locked on every dwell it checked; %d dwells not used because the PC sent the '
                          'band change late (not drawn)' % (b[0]['slots'] - b[0]['locked']))
          # is the lab tone actually there? (the receiver can be perfect while the
          # transmitter is silent -- say which one it is)
          ms = self.ph_meter.get_stats()
          row = [v for k, v in ms.items() if abs(k - tb) <= 1e6]
          w, t = (row[0]['windows'], row[0]['tone']) if row else (0, 0)
          last = self._fast_state.setdefault('tone_seen', {'w': 0, 't': 0, 'band': tb})
          if last['band'] != tb:
              last.update(w=w, t=t, band=tb)
          dw, dt = w - last['w'], t - last['t']
          last['w'], last['t'] = w, t
          if dw > 0 and dt == 0:
              self._show_lbl.setStyleSheet('font-size: 13pt; font-weight: bold; color: #c00000;')
              self._show_lbl.setText('SHOWING:  %g GHz  --  NO TONE right now (0/%d dwells): the lab '
                                     'transmitter is not sending on this band. Receiver OK: %s'
                                     % (tb / 1e9, dw, lock_txt))
          else:
              self._show_lbl.setStyleSheet('font-size: 13pt; font-weight: bold; color: #1a4d8f;')
              self._show_lbl.setText('SHOWING:  %g GHz  (LAB TONE band) -- its 5 ms dwells only, %s%s'
                                     % (tb / 1e9, lock_txt,
                                        '' if dw <= 0 or dt == dw else
                                        '  -- tone in only %d/%d dwells' % (dt, dw)))

      self._ph_val = []
      for _c in range(4):
          _t = _Qt.QLabel('ch%d - ch0 phase offset (deg)' % _c)
          _t.setStyleSheet('font-size: 13pt; font-weight: bold;')
          _v = _Qt.QLabel('waiting')
          _v.setStyleSheet('font-family: monospace; font-size: 15pt;')
          self.tabs_grid_layout_0.addWidget(_t, 8 + _c, 0, 1, 1)
          self.tabs_grid_layout_0.addWidget(_v, 8 + _c, 1, 1, 2)
          self._ph_val.append(_v)

      def _ph_poll():
          row = self.ph_meter.last_row
          for _c, _v in enumerate(self._ph_val):
              if row is None:
                  _v.setText('waiting for the first dwell')
                  _v.setStyleSheet('font-family: monospace; font-size: 15pt; color: gray;')
              elif _c == 0:
                  _v.setText('   0.000 deg  (reference)')
                  _v.setStyleSheet('font-family: monospace; font-size: 15pt;')
              elif row[_c] != row[_c]:
                  _v.setText('NO TONE - nothing measured')
                  _v.setStyleSheet('font-family: monospace; font-size: 15pt; color: #c00000; font-weight: bold;')
              else:
                  _v.setText('%+8.3f deg   (average of the last 20 dwells)' % row[_c])
                  _v.setStyleSheet('font-family: monospace; font-size: 15pt;')

      self._dwell_lbl = _Qt.QLabel('SAMPLES RECEIVED: 0        DWELLS: 0')
      self._dwell_lbl.setStyleSheet('font-family: monospace; font-size: 16pt; font-weight: bold;')
      self.tabs_grid_layout_0.addWidget(self._dwell_lbl, 12, 0, 1, 3)

      # the HackRF's clock correction measured at start (run_hop.sh --burst): the
      # tone's distance from where it should be then shows how far the two clocks
      # have drifted apart since
      try:
          self._ppm_start = float(open(os.path.join(os.path.dirname(os.path.abspath(__file__)),
                                                     'hackrf_ppm.txt')).read())
      except Exception:
          self._ppm_start = None

      def _dwell_poll():
          # line 1: two independent counters kept by the engine as the X310 delivers
          #   SAMPLES = every dwell sample received, added packet by packet
          #   DWELLS  = +1 for every complete dwell burst
          # line 2: the last dwell of the lab tone's band, measured on its samples
          bi = self.twinrx_radio_source_0.get_burst_info()
          if bi:
              l1 = 'SAMPLES RECEIVED: %s        DWELLS: %s' % (format(bi['dwell_samples_total'], ','),
                                                             format(bi['dwells_total'], ','))
          else:
              l1 = 'SAMPLES RECEIVED: -        DWELLS: -   (burst mode only)'
          tb = float(self.tone_band)
          w = [v for k, v in self.ph_meter.last_windows.items() if abs(k - tb) <= 1e6]
          if w and w[0]['tone']:
              l2 = 'TONE (%g GHz): %+.1f Hz        CYCLES in the last dwell (counted): %.2f' % (
                  tb / 1e9, w[0]['tone_hz'], abs(w[0]['cycles_counted']))
          elif w and w[0].get('near_dc'):
              l2 = ('TONE (%g GHz): %+.0f Hz -- inside +/-2 kHz of 0 Hz (receiver leakage): NOT measured'
                    % (tb / 1e9, w[0]['tone_hz']))
          else:
              l2 = 'TONE (%g GHz): no tone in the last dwell' % (tb / 1e9)
          self._dwell_lbl.setText(l1 + '\n' + l2)

      self._dwell_timer = QtCore.QTimer(self)
      self._dwell_timer.timeout.connect(_dwell_poll)
      self._dwell_timer.start(100)

      def _now_poll():
          st, f = self.twinrx_radio_source_0.get_current()
          if f:
              self._now_lbl.setText('RECEIVING NOW:  %g GHz  (%s)' % (f / 1e9, st))
      self._now_timer = QtCore.QTimer(self)
      self._now_timer.timeout.connect(_now_poll)
      self._now_timer.start(40)

      def _band_poll():
          for _f, _m, _l, _last in self._band_lbl:
              _s = _m.get_stats()
              _row = [v for k, v in _s.items() if abs(k - _f) <= 1e6]
              _w = _row[0]['windows'] if _row else 0
              _t = _row[0]['tone'] if _row else 0
              dw, dt = _w - _last['w'], _t - _last['t']
              _last['w'], _last['t'] = _w, _t
              _ph = _m.recent(20)
              _num = ('  '.join('ch%d-ch0 %+7.2f deg' % (c + 1, v) for c, v in enumerate(_ph))
                      if _ph is not None and dt > 0 else '  '.join('ch%d-ch0     nan    ' % (c + 1) for c in range(3)))
              if dw <= 0:
                  _state = 'NO DWELLS ARRIVING   '
              elif dt == dw:
                  _state = 'SIGNAL (%2d/%2d dwells)' % (dt, dw)
              elif dt == 0:
                  _state = 'FLAT   ( 0/%2d dwells)' % dw
              else:
                  _state = 'PARTLY (%2d/%2d dwells)' % (dt, dw)
              _l.setText('%-8s  %s   %s' % ('%g GHz' % (_f / 1e9), _state, _num))

      def _cal_poll():
          if self._cal.status != self._fast_state.get('cal'):
              self._fast_state['cal'] = self._cal.status
              if self._cal.status != 'not run':
                  self._cal_lbl.setText('CAL: ' + self._cal.status)
          self._cal_btn.setEnabled(not self._cal.busy)

      self._follow_timer = QtCore.QTimer(self)
      self._follow_timer.timeout.connect(_poll)
      self._follow_timer.timeout.connect(_cal_poll)
      self._follow_timer.timeout.connect(_band_poll)
      self._follow_timer.timeout.connect(_lock_poll)
      self._now_timer_ph = QtCore.QTimer(self)
      self._now_timer_ph.timeout.connect(_ph_poll)
      self._now_timer_ph.start(200)
      self._follow_timer.start(500)
    comment: |-
      Follows the block so the CURRENT BAND label
      tracks; the block does the hopping itself.
    section: main_after_start
  states: {}
- name: snippet_lo_config
  id: snippet
  parameters:
    code: |
      # LO routing and the timed tune happen INSIDE the TwinRX USRP Source
      # block, so nothing LO-related belongs here.
      #
      # The calibration source is a HackRF One, started outside this flowgraph
      # (run_hop.sh, or: hackrf --freq 2.4e9 --vga 16). It cannot be launched
      # from here: the HackRF needs the system GNU Radio 3.10 while this runs
      # under 3.8, and keeping libuhd 4.1 out of the transmitter's process
      # matters because the X310's FPGA image is built for UHD 3.15.
      print('[*] Calibration source: HackRF One (started separately).')
    comment: The transmitter runs in its own process; see run_hop.sh.
    section: main_after_init
  states: {}
- name: snippet_lo_stop
  id: snippet
  parameters:
    code: |
      # twinrx_radio_source stops its scheduler and the stream inside the
      # flowgraph's own stop, before the device goes away. Only the GUI poll is
      # left to stop here.
      self._hop_run = False
      for _t in ("_follow_timer", "_now_timer", "_now_timer_ph", "_dwell_timer"):
          try:
              getattr(self, _t).stop()
          except Exception:
              pass
      self._twinrx_run = False
    comment: |-
      Stops hopping before teardown -- otherwise the thread
      tunes a device that is being destroyed.
    section: main_after_stop
  states: {}
- name: snippet_lo_watch
  id: snippet
  parameters:
    code: |
      print('TwinRX USRP Source block owns LO routing and tuning.')
    section: main_after_start
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Hopping
    label1: Spectra
    label2: Switching
    label3: MON
    num_tabs: '4'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX1
    ant1: RX2
    ant2: RX1
    ant3: RX2
    center_freq0: center_freq
    center_freq1: center_freq
    center_freq2: center_freq
    center_freq3: center_freq
    clock_rate: 200e6
    clock_source0: internal
    comment: |-
      TwinRX REQUIRES master_clock_rate = 200 MHz.
      LO controls are deliberately hidden here: GRC would emit
      set_lo_source() AFTER set_center_freq(), which is the wrong
      order.  The Python Snippet does it properly instead.
    dc_offs_enb0: ''
    dc_offs_enb1: ''
    dc_offs_enb2: ''
    dc_offs_enb3: ''
    dev_addr: '"type=x300"'
    dev_args: '""'
    gain0: gain
    gain1: gain
    gain2: gain
    gain3: gain
    iq_imbal_enb0: ''
    iq_imbal_enb1: ''
    iq_imbal_enb2: ''
    iq_imbal_enb3: ''
    nchan: '4'
    norm_gain0: 'False'
    norm_gain1: 'False'
    norm_gain2: 'False'
    norm_gain3: 'False'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sd_spec0: subdev
    sync: none
    time_source0: internal
    type: fc32
  states: {state: disabled}
- name: twinrx_radio_source_0
  id: switch_source
  parameters:
    samp_rate: samp_rate
    addresses: '''addr=192.168.10.2'''
    num_bands: '3'
    settle: '0.007'
    guard_pre: '0.00025'
    gain_trim: (0.0, -13.3, 1.5, -1.7)
    start_delay: '0.5'
    tx_control: '"127.0.0.1:5123"'
    park_freq: tone_band
    lock_check: '0.0065'
    min_slack: '0.003'
    recv_buff_size: '33554432'
    rt_priority: '90'
    preroll: '0.00025'
    comment: DF on outputs 0-3 (as guru_burst), MON on 4-7; mode switched on the radio clock
    freq_0: '2400000000.0'
    gain_0: '46.0'
    dwell_0: '0.005'
    freq_1: '5200000000.0'
    gain_1: '60.0'
    dwell_1: '0.005'
    freq_2: '5800000000.0'
    gain_2: '69.0'
    dwell_2: '0.005'
    freq_3: 1.0e9
    gain_3: '46'
    dwell_3: '0.005'
    mon_freqs: (900000000.0, 2400000000.0, 5200000000.0, 5800000000.0)
    mon_gains: (60.0, 46.0, 60.0, 69.0)
    mon_dwell: '0.02'
    start_mode: mode
    switch_gap: '0.01'
  states: {}
- name: tone_band
  id: variable_qtgui_chooser
  parameters:
    gui_hint: tabs@0:1,0,1,3
    label: LAB TONE (HackRF) BAND
    type: real
    num_opts: '4'
    value: '2400000000.0'
    orient: Qt.QHBoxLayout
    option0: '2400000000.0'
    label0: 2.4 GHz
    option1: '5200000000.0'
    label1: 5.2 GHz
    option2: '5800000000.0'
    label2: 5.8 GHz
    option3: '900000000.0'
    label3: 900 MHz (MON ch0 only)
  states: {}
- name: sched_state
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:2,0,1,3
    label: SCHEDULE
    type: string
    value: '''starting'''
  states: {}
- name: spec_sel
  id: hop_band_select
  parameters:
    num_channels: '4'
    band_freq: tone_band
    frame_tag: ''''''
    frame_offset: '100'
    comment: 'Spectrum: dwell samples of the lab tone''s band'
  states: {}
- name: met_0
  id: hop_phase_meter
  parameters:
    num_channels: '4'
    band_freq: '2400000000.0'
    samp_rate: samp_rate
    f_lo: tone_offset - disp_bw/2 + 10e3
    f_hi: tone_offset + disp_bw/2 - 10e3
    remove_dc: 'False'
    dc_guard: '0'
    snr_min_db: '20'
    avg_windows: '20'
    report_s: '5'
    comment: chN - ch0 per 2.4 GHz dwell window, NaN when flat
  states: {}
- name: met_0_null0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: met_0_null1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: met_0_null2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: met_0_null3
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: met_1
  id: hop_phase_meter
  parameters:
    num_channels: '4'
    band_freq: '5200000000.0'
    samp_rate: samp_rate
    f_lo: tone_offset - disp_bw/2 + 10e3
    f_hi: tone_offset + disp_bw/2 - 10e3
    remove_dc: 'False'
    dc_guard: '0'
    snr_min_db: '20'
    avg_windows: '20'
    report_s: '5'
    comment: chN - ch0 per 5.2 GHz dwell window, NaN when flat
  states: {}
- name: met_1_null0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: met_1_null1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: met_1_null2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: met_1_null3
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: met_2
  id: hop_phase_meter
  parameters:
    num_channels: '4'
    band_freq: '5800000000.0'
    samp_rate: samp_rate
    f_lo: tone_offset - disp_bw/2 + 10e3
    f_hi: tone_offset + disp_bw/2 - 10e3
    remove_dc: 'False'
    dc_guard: '0'
    snr_min_db: '20'
    avg_windows: '20'
    report_s: '5'
    comment: chN - ch0 per 5.8 GHz dwell window, NaN when flat
  states: {}
- name: met_2_null0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: met_2_null1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: met_2_null2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: met_2_null3
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: wave_sel
  id: hop_band_select
  parameters:
    num_channels: '4'
    band_freq: tone_band
    frame_tag: '''hop_frame'''
    frame_offset: '100'
    remove_dc: 'False'
    narrow_hz: '10000.0'
    samp_rate: samp_rate
    comment: dwell samples of the lab tone's band
  states: {}
- name: wave_sink
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: red
    color2: blue
    color4: magenta
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: tabs@0:7,0,1,3
    label1: Ch0 RF A/RX2 - LO external
    label2: Ch1 RF A/RX1 - LO external
    label3: Ch2 RF B/RX1 - LO internal (MASTER, exports)
    label4: Ch3 RF B/RX2 - LO companion
    name: '"RF waveforms of the LAB TONE band (its 5 ms dwells only), all 4 channels"'
    nconnections: '4'
    size: '1000'
    srate: time_srate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '''hop_frame'''
    type: float
    width1: '2'
    width2: '2'
    width3: '2'
    width4: '2'
    ymax: '0.6'
    ymin: '-0.6'
  states: {}
- name: wave_c2r_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: wave_rs_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: time_interp
    taps: firdes.low_pass(time_interp * disp_gain, time_srate, disp_bw, disp_interp_trans, firdes.WIN_HAMMING)
    type: ccc
  states: {}
- name: wave_c2r_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: wave_rs_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: time_interp
    taps: firdes.low_pass(time_interp * disp_gain, time_srate, disp_bw, disp_interp_trans, firdes.WIN_HAMMING)
    type: ccc
  states: {}
- name: wave_c2r_2
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: wave_rs_2
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: time_interp
    taps: firdes.low_pass(time_interp * disp_gain, time_srate, disp_bw, disp_interp_trans, firdes.WIN_HAMMING)
    type: ccc
  states: {}
- name: wave_c2r_3
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: wave_rs_3
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: time_interp
    taps: firdes.low_pass(time_interp * disp_gain, time_srate, disp_bw, disp_interp_trans, firdes.WIN_HAMMING)
    type: ccc
  states: {}
- name: ph_meter
  id: hop_phase_meter
  parameters:
    num_channels: '4'
    band_freq: tone_band
    samp_rate: samp_rate
    f_lo: tone_offset - disp_bw/2 + 10e3
    f_hi: tone_offset + disp_bw/2 - 10e3
    remove_dc: 'False'
    dc_guard: '0'
    snr_min_db: '20'
    avg_windows: '20'
    report_s: 1e9
    comment: 'readouts: chN - ch0 of the band shown above, NaN when flat'
  states: {}
- name: ph_meter_null0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: ph_meter_null1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: ph_meter_null2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: ph_meter_null3
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: sw_sink
  id: qtgui_time_sink_x
  parameters:
    color1: red
    color2: blue
    color4: magenta
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: tabs@2:0,0,1,3
    label1: Ch0 RF A/RX2 - LO external
    label2: Ch1 RF A/RX1 - LO external
    label3: Ch2 RF B/RX1 - LO internal (MASTER, exports)
    label4: Ch3 RF B/RX2 - LO companion
    name: '"One cycle:  0-7 ms switch | 7-12 ms 2.4 GHz  |  12-19 ms switch | 19-24 ms 5.2 GHz  |  24-31 ms switch | 31-36 ms 5.8 GHz"'
    nconnections: '4'
    size: '3600'
    srate: '100000.0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '''hop_cycle'''
    type: float
    update_time: '0.20'
    width1: '2'
    width2: '2'
    width3: '2'
    width4: '2'
    ylabel: '|amplitude|'
    ymax: '0.5'
    ymin: '-0.05'
  states: {}
- name: sw_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: sw_avg_0
  id: blocks_moving_average_xx
  parameters:
    type: float
    length: '20'
    scale: disp_gain * 1.0/20
    max_iter: '4000'
    comment: same display gain as the RF waveform plot
  states: {}
- name: sw_dec_0
  id: blocks_keep_one_in_n
  parameters:
    type: float
    n: '20'
  states: {}
- name: sw_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: sw_avg_1
  id: blocks_moving_average_xx
  parameters:
    type: float
    length: '20'
    scale: disp_gain * 1.0/20
    max_iter: '4000'
    comment: same display gain as the RF waveform plot
  states: {}
- name: sw_dec_1
  id: blocks_keep_one_in_n
  parameters:
    type: float
    n: '20'
  states: {}
- name: sw_mag_2
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: sw_avg_2
  id: blocks_moving_average_xx
  parameters:
    type: float
    length: '20'
    scale: disp_gain * 1.0/20
    max_iter: '4000'
    comment: same display gain as the RF waveform plot
  states: {}
- name: sw_dec_2
  id: blocks_keep_one_in_n
  parameters:
    type: float
    n: '20'
  states: {}
- name: sw_mag_3
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: sw_avg_3
  id: blocks_moving_average_xx
  parameters:
    type: float
    length: '20'
    scale: disp_gain * 1.0/20
    max_iter: '4000'
    comment: same display gain as the RF waveform plot
  states: {}
- name: sw_dec_3
  id: blocks_keep_one_in_n
  parameters:
    type: float
    n: '20'
  states: {}
- name: mode
  id: variable_qtgui_chooser
  parameters:
    comment: 'switch_source.set_mode(): taken at the next slot boundary on the radio clock'
    gui_hint: 0,0,1,1
    label: MODE
    type: string
    num_opts: '2'
    value: '''df'''
    orient: Qt.QHBoxLayout
    option0: '''df'''
    label0: DF - shared LO, coherent hopping
    option1: '''mon'''
    label1: MON - own LO per channel
  states: {}
- name: mode_state
  id: variable_qtgui_label
  parameters:
    comment: set by the switch snippet from switch_source.get_mode_info() (engine counters)
    gui_hint: 0,1,1,3
    type: string
    value: '''starting'''
  states: {}
- name: mon_lbl0
  id: variable_qtgui_label
  parameters:
    comment: set by the switch snippet
    gui_hint: tabs@3:0,0,1,2
    label: LO0 ch0 A/RX1  0.9 GHz
    type: string
    value: '''MON not running'''
  states: {}
- name: mon_spec0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: MON output 4
    fc: '900000000.0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: tabs@3:1,0,2,1
    label1: ch0 A/RX1
    name: '"MON LO0 ch0 - spectrum"'
    type: complex
    width1: '2'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
  states: {}
- name: mon_time0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: whole 4096-sample blocks of MON output, one in 10
    entags: 'False'
    grid: 'True'
    gui_hint: tabs@3:1,1,2,1
    label1: I
    label2: Q
    name: '"MON LO0 ch0 - time (real samples, I and Q)"'
    size: '400'
    srate: samp_rate
    type: complex
    width1: '2'
    width2: '2'
    ymax: '0.1'
    ymin: '-0.1'
  states: {}
- name: mon_s2v0
  id: blocks_stream_to_vector
  parameters:
    type: complex
    num_items: '4096'
  states: {}
- name: mon_k1n0
  id: blocks_keep_one_in_n
  parameters:
    type: complex
    n: '10'
    vlen: '4096'
  states: {}
- name: mon_v2s0
  id: blocks_vector_to_stream
  parameters:
    type: complex
    num_items: '4096'
  states: {}
- name: mon_snap_s2v0
  id: blocks_stream_to_vector
  parameters:
    type: complex
    num_items: '8192'
  states: {}
- name: mon_snap_k1n0
  id: blocks_keep_one_in_n
  parameters:
    type: complex
    n: '25'
    vlen: '8192'
  states: {}
- name: mon_probe0
  id: blocks_probe_signal_vx
  parameters:
    type: complex
    vlen: '8192'
  states: {}
- name: mon_lbl1
  id: variable_qtgui_label
  parameters:
    comment: set by the switch snippet
    gui_hint: tabs@3:0,2,1,2
    label: LO1 ch1 A/RX2  2.4 GHz
    type: string
    value: '''MON not running'''
  states: {}
- name: mon_spec1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: MON output 5
    fc: '2400000000.0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: tabs@3:1,2,2,1
    label1: ch1 A/RX2
    name: '"MON LO1 ch1 - spectrum"'
    type: complex
    width1: '2'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
  states: {}
- name: mon_time1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: whole 4096-sample blocks of MON output, one in 10
    entags: 'False'
    grid: 'True'
    gui_hint: tabs@3:1,3,2,1
    label1: I
    label2: Q
    name: '"MON LO1 ch1 - time (real samples, I and Q)"'
    size: '400'
    srate: samp_rate
    type: complex
    width1: '2'
    width2: '2'
    ymax: '0.1'
    ymin: '-0.1'
  states: {}
- name: mon_s2v1
  id: blocks_stream_to_vector
  parameters:
    type: complex
    num_items: '4096'
  states: {}
- name: mon_k1n1
  id: blocks_keep_one_in_n
  parameters:
    type: complex
    n: '10'
    vlen: '4096'
  states: {}
- name: mon_v2s1
  id: blocks_vector_to_stream
  parameters:
    type: complex
    num_items: '4096'
  states: {}
- name: mon_snap_s2v1
  id: blocks_stream_to_vector
  parameters:
    type: complex
    num_items: '8192'
  states: {}
- name: mon_snap_k1n1
  id: blocks_keep_one_in_n
  parameters:
    type: complex
    n: '25'
    vlen: '8192'
  states: {}
- name: mon_probe1
  id: blocks_probe_signal_vx
  parameters:
    type: complex
    vlen: '8192'
  states: {}
- name: mon_lbl2
  id: variable_qtgui_label
  parameters:
    comment: set by the switch snippet
    gui_hint: tabs@3:3,0,1,2
    label: LO2 ch2 B/RX1  5.2 GHz
    type: string
    value: '''MON not running'''
  states: {}
- name: mon_spec2
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: MON output 6
    fc: '5200000000.0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: tabs@3:4,0,2,1
    label1: ch2 B/RX1
    name: '"MON LO2 ch2 - spectrum"'
    type: complex
    width1: '2'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
  states: {}
- name: mon_time2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: whole 4096-sample blocks of MON output, one in 10
    entags: 'False'
    grid: 'True'
    gui_hint: tabs@3:4,1,2,1
    label1: I
    label2: Q
    name: '"MON LO2 ch2 - time (real samples, I and Q)"'
    size: '400'
    srate: samp_rate
    type: complex
    width1: '2'
    width2: '2'
    ymax: '0.1'
    ymin: '-0.1'
  states: {}
- name: mon_s2v2
  id: blocks_stream_to_vector
  parameters:
    type: complex
    num_items: '4096'
  states: {}
- name: mon_k1n2
  id: blocks_keep_one_in_n
  parameters:
    type: complex
    n: '10'
    vlen: '4096'
  states: {}
- name: mon_v2s2
  id: blocks_vector_to_stream
  parameters:
    type: complex
    num_items: '4096'
  states: {}
- name: mon_snap_s2v2
  id: blocks_stream_to_vector
  parameters:
    type: complex
    num_items: '8192'
  states: {}
- name: mon_snap_k1n2
  id: blocks_keep_one_in_n
  parameters:
    type: complex
    n: '25'
    vlen: '8192'
  states: {}
- name: mon_probe2
  id: blocks_probe_signal_vx
  parameters:
    type: complex
    vlen: '8192'
  states: {}
- name: mon_lbl3
  id: variable_qtgui_label
  parameters:
    comment: set by the switch snippet
    gui_hint: tabs@3:3,2,1,2
    label: LO3 ch3 B/RX2  5.8 GHz
    type: string
    value: '''MON not running'''
  states: {}
- name: mon_spec3
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: MON output 7
    fc: '5800000000.0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: tabs@3:4,2,2,1
    label1: ch3 B/RX2
    name: '"MON LO3 ch3 - spectrum"'
    type: complex
    width1: '2'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
  states: {}
- name: mon_time3
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: whole 4096-sample blocks of MON output, one in 10
    entags: 'False'
    grid: 'True'
    gui_hint: tabs@3:4,3,2,1
    label1: I
    label2: Q
    name: '"MON LO3 ch3 - time (real samples, I and Q)"'
    size: '400'
    srate: samp_rate
    type: complex
    width1: '2'
    width2: '2'
    ymax: '0.1'
    ymin: '-0.1'
  states: {}
- name: mon_s2v3
  id: blocks_stream_to_vector
  parameters:
    type: complex
    num_items: '4096'
  states: {}
- name: mon_k1n3
  id: blocks_keep_one_in_n
  parameters:
    type: complex
    n: '10'
    vlen: '4096'
  states: {}
- name: mon_v2s3
  id: blocks_vector_to_stream
  parameters:
    type: complex
    num_items: '4096'
  states: {}
- name: mon_snap_s2v3
  id: blocks_stream_to_vector
  parameters:
    type: complex
    num_items: '8192'
  states: {}
- name: mon_snap_k1n3
  id: blocks_keep_one_in_n
  parameters:
    type: complex
    n: '25'
    vlen: '8192'
  states: {}
- name: mon_probe3
  id: blocks_probe_signal_vx
  parameters:
    type: complex
    vlen: '8192'
  states: {}
- name: snippet_switch
  id: snippet
  parameters:
    section: main_after_start
    priority: '5'
    code: |
      # MON <-> DF: status twice a second from the engine's own counters (never a
      # radio read here: it would wait behind the timed commands), and the control
      # API on udp://:0 ('mode df' | 'mode mon' | 'status').
      import json
      import socket
      import threading
      import numpy as np
      from PyQt5 import QtCore

      _src = self.twinrx_radio_source_0
      _FS = float(self.samp_rate)
      _MONF = [900000000.0, 2400000000.0, 5200000000.0, 5800000000.0]
      self._sw_api_mode = None

      def _readout(x):
          N = len(x)
          S = np.abs(np.fft.fft(x * np.hanning(N).astype(np.float32))) ** 2
          F = np.fft.fftfreq(N, 1.0 / _FS)
          k = int(np.argmax(np.where(np.abs(F) >= 20e3, S, 0)))
          return float(F[k]), float(10 * np.log10(S[k] / (np.median(S) + 1e-30))), float(np.abs(x).max())

      def _sw_poll():
          mi = _src.get_mode_info()
          last = mi["last_request_to_dwell_ms"]
          txt = ("NOW %s%s | switches %d (not used %d) | last: to %s, request -> first dwell %s, %s | "
                 "samples: MON %d, DF %d" % (
                     mi["mode"], "" if mi["requested"] == mi["mode"] else "  (switching to %s)" % mi["requested"],
                     mi["switches"], mi["switches_bad"], mi["last_switch_to"] or "-",
                     "%.1f ms" % last if last else "-", mi["last_switch_ok"] if mi["switches"] else "-",
                     mi["mon_dwell_samples"], mi["df_dwell_samples"]))
          self.set_mode_state(txt)
          for c in range(4):
              lk = mi["mon_lock"][c]
              s = "%s | MON samples (engine) %d, MON slots used %d, not used %d" % (
                  "LOCKED" if lk else ("LOCK NOT READ YET" if lk is None else "NOT LOCKED"),
                  mi["mon_dwell_samples"], mi["mon_slots_verified"], mi["mon_slots_not_used"])
              if mi["mode"] != "MON":
                  s = "not in MON (mode %s) | last: " % mi["mode"] + s
              x = np.asarray(getattr(self, "mon_probe%d" % c).level(), dtype=np.complex64)
              if len(x) and mi["mode"] == "MON":
                  # a block that overlaps a switch gap (the zeros of DF time) is no MON reading
                  if np.count_nonzero(x == 0) > 16:
                      s += " | newest block overlaps a switch: not read"
                  else:
                      f, db, pk = _readout(x)
                      s += " | newest %d samples: %s %+.1f kHz %.1f dB | ADC peak %.3f%s" % (
                          len(x), "TONE" if db >= 30 else "no tone, strongest line", f / 1e3, db, pk,
                          "  OVERLOAD" if pk > 0.5 else "")
              getattr(self, "set_mon_lbl%d" % c)(s)
          # the API may have changed the mode: show it on the selector (GUI thread)
          if self._sw_api_mode and self._sw_api_mode != self.mode:
              self.set_mode(self._sw_api_mode)
          self._sw_api_mode = None

      self._sw_timer = QtCore.QTimer()
      self._sw_timer.timeout.connect(_sw_poll)
      self._sw_timer.start(500)

      def _api():
          sk = socket.socket(socket.AF_INET, socket.SOCK_DGRAM)
          try:
              sk.bind(("", 0))
          except OSError as e:
              print("[switch] control API NOT started (%s)" % e)
              return
          print("[switch] control API on udp://:0  ('mode df' | 'mode mon' | 'status')")
          while True:
              data, peer = sk.recvfrom(256)
              cmd = data.decode(errors="ignore").split()
              try:
                  if len(cmd) == 2 and cmd[0] == "mode" and cmd[1] in ("df", "mon"):
                      _src.set_mode(cmd[1])            # the engine takes it at the next slot
                      self._sw_api_mode = cmd[1]       # the selector follows in the GUI thread
                      reply = {"ok": True, "requested": cmd[1]}
                  elif cmd and cmd[0] == "status":
                      reply = {"ok": True, "mode": _src.get_mode_info(), "schedule": _src.get_schedule_stats()}
                  else:
                      reply = {"ok": False, "error": "commands: 'mode df' | 'mode mon' | 'status'"}
              except Exception as e:
                  reply = {"ok": False, "error": "%s: %s" % (type(e).__name__, e)}
              sk.sendto(json.dumps(reply, default=str).encode(), peer)

      if False:
          threading.Thread(target=_api, daemon=True).start()
      else:
          print("[switch] no control API: the mode changes only with the MODE selector")
  states: {}

connections:
- [bp_0, '0', phase_correct_hopping_0, '0']
- [bp_1, '0', phase_correct_hopping_0, '3']
- [bp_2, '0', phase_correct_hopping_0, '1']
- [bp_3, '0', phase_correct_hopping_0, '2']
- [twinrx_radio_source_0, '0', bp_0, '0']
- [twinrx_radio_source_0, '1', bp_2, '0']
- [twinrx_radio_source_0, '2', bp_3, '0']
- [twinrx_radio_source_0, '3', bp_1, '0']
- [twinrx_radio_source_0, '0', spec_sel, '0']
- [spec_sel, '0', qtgui_freq_sink_x_0, '0']
- [twinrx_radio_source_0, '1', spec_sel, '1']
- [spec_sel, '1', qtgui_freq_sink_x_0, '1']
- [twinrx_radio_source_0, '2', spec_sel, '2']
- [spec_sel, '2', qtgui_freq_sink_x_0, '2']
- [twinrx_radio_source_0, '3', spec_sel, '3']
- [spec_sel, '3', qtgui_freq_sink_x_0, '3']
- [phase_correct_hopping_0, '0', met_0, '0']
- [met_0, '0', met_0_null0, '0']
- [phase_correct_hopping_0, '1', met_0, '1']
- [met_0, '1', met_0_null1, '0']
- [phase_correct_hopping_0, '2', met_0, '2']
- [met_0, '2', met_0_null2, '0']
- [phase_correct_hopping_0, '3', met_0, '3']
- [met_0, '3', met_0_null3, '0']
- [phase_correct_hopping_0, '0', met_1, '0']
- [met_1, '0', met_1_null0, '0']
- [phase_correct_hopping_0, '1', met_1, '1']
- [met_1, '1', met_1_null1, '0']
- [phase_correct_hopping_0, '2', met_1, '2']
- [met_1, '2', met_1_null2, '0']
- [phase_correct_hopping_0, '3', met_1, '3']
- [met_1, '3', met_1_null3, '0']
- [phase_correct_hopping_0, '0', met_2, '0']
- [met_2, '0', met_2_null0, '0']
- [phase_correct_hopping_0, '1', met_2, '1']
- [met_2, '1', met_2_null1, '0']
- [phase_correct_hopping_0, '2', met_2, '2']
- [met_2, '2', met_2_null2, '0']
- [phase_correct_hopping_0, '3', met_2, '3']
- [met_2, '3', met_2_null3, '0']
- [phase_correct_hopping_0, '0', wave_sel, '0']
- [wave_sel, '0', wave_rs_0, '0']
- [wave_rs_0, '0', wave_c2r_0, '0']
- [wave_c2r_0, '0', wave_sink, '0']
- [phase_correct_hopping_0, '1', wave_sel, '1']
- [wave_sel, '1', wave_rs_1, '0']
- [wave_rs_1, '0', wave_c2r_1, '0']
- [wave_c2r_1, '0', wave_sink, '1']
- [phase_correct_hopping_0, '2', wave_sel, '2']
- [wave_sel, '2', wave_rs_2, '0']
- [wave_rs_2, '0', wave_c2r_2, '0']
- [wave_c2r_2, '0', wave_sink, '2']
- [phase_correct_hopping_0, '3', wave_sel, '3']
- [wave_sel, '3', wave_rs_3, '0']
- [wave_rs_3, '0', wave_c2r_3, '0']
- [wave_c2r_3, '0', wave_sink, '3']
- [phase_correct_hopping_0, '0', ph_meter, '0']
- [ph_meter, '0', ph_meter_null0, '0']
- [phase_correct_hopping_0, '1', ph_meter, '1']
- [ph_meter, '1', ph_meter_null1, '0']
- [phase_correct_hopping_0, '2', ph_meter, '2']
- [ph_meter, '2', ph_meter_null2, '0']
- [phase_correct_hopping_0, '3', ph_meter, '3']
- [ph_meter, '3', ph_meter_null3, '0']
- [phase_correct_hopping_0, '0', sw_mag_0, '0']
- [sw_mag_0, '0', sw_avg_0, '0']
- [sw_avg_0, '0', sw_dec_0, '0']
- [sw_dec_0, '0', sw_sink, '0']
- [phase_correct_hopping_0, '1', sw_mag_1, '0']
- [sw_mag_1, '0', sw_avg_1, '0']
- [sw_avg_1, '0', sw_dec_1, '0']
- [sw_dec_1, '0', sw_sink, '1']
- [phase_correct_hopping_0, '2', sw_mag_2, '0']
- [sw_mag_2, '0', sw_avg_2, '0']
- [sw_avg_2, '0', sw_dec_2, '0']
- [sw_dec_2, '0', sw_sink, '2']
- [phase_correct_hopping_0, '3', sw_mag_3, '0']
- [sw_mag_3, '0', sw_avg_3, '0']
- [sw_avg_3, '0', sw_dec_3, '0']
- [sw_dec_3, '0', sw_sink, '3']
- [twinrx_radio_source_0, '4', mon_s2v0, '0']
- [mon_s2v0, '0', mon_k1n0, '0']
- [mon_k1n0, '0', mon_v2s0, '0']
- [mon_v2s0, '0', mon_spec0, '0']
- [mon_v2s0, '0', mon_time0, '0']
- [twinrx_radio_source_0, '4', mon_snap_s2v0, '0']
- [mon_snap_s2v0, '0', mon_snap_k1n0, '0']
- [mon_snap_k1n0, '0', mon_probe0, '0']
- [twinrx_radio_source_0, '5', mon_s2v1, '0']
- [mon_s2v1, '0', mon_k1n1, '0']
- [mon_k1n1, '0', mon_v2s1, '0']
- [mon_v2s1, '0', mon_spec1, '0']
- [mon_v2s1, '0', mon_time1, '0']
- [twinrx_radio_source_0, '5', mon_snap_s2v1, '0']
- [mon_snap_s2v1, '0', mon_snap_k1n1, '0']
- [mon_snap_k1n1, '0', mon_probe1, '0']
- [twinrx_radio_source_0, '6', mon_s2v2, '0']
- [mon_s2v2, '0', mon_k1n2, '0']
- [mon_k1n2, '0', mon_v2s2, '0']
- [mon_v2s2, '0', mon_spec2, '0']
- [mon_v2s2, '0', mon_time2, '0']
- [twinrx_radio_source_0, '6', mon_snap_s2v2, '0']
- [mon_snap_s2v2, '0', mon_snap_k1n2, '0']
- [mon_snap_k1n2, '0', mon_probe2, '0']
- [twinrx_radio_source_0, '7', mon_s2v3, '0']
- [mon_s2v3, '0', mon_k1n3, '0']
- [mon_k1n3, '0', mon_v2s3, '0']
- [mon_v2s3, '0', mon_spec3, '0']
- [mon_v2s3, '0', mon_time3, '0']
- [twinrx_radio_source_0, '7', mon_snap_s2v3, '0']
- [mon_snap_s2v3, '0', mon_snap_k1n3, '0']
- [mon_snap_k1n3, '0', mon_probe3, '0']

metadata:
  file_format: 1
