options:
  parameters:
    author: shankar
    comment: |-
      USRP-2945 (X310 + 2x TwinRX) LO configuration and phase-coherence test.
      GNU Radio 3.8 / UHD 3.15.
      All four channels are driven from ONE synthesiser, tuned with timed commands.
    description: TwinRX LO sharing / phase coherence test bench
    generate_options: qt_gui
    id: guru
    output_language: python
    title: 'Guru: USRP-2945 4-Channel Coherent Receiver & Phase Alignment'
  states: {}

blocks:
- name: avg_len
  id: variable
  parameters:
    comment: |-
      Coherent averaging length for the phase estimate.
      65536 samples = 65 ms at 1 Msps, comparable to what
      twinrx_lo_check.py integrates. The old 4096 averaged 24x
      less and made the GUI look far noisier than the CLI for
      the same signal.
    value: '65536'
  states: {}
- name: band
  id: variable_qtgui_label
  parameters:
    comment: |-
      Shows which band the receiver is on right now.
      It depends on center_freq, so GRC refreshes it from
      set_center_freq() -- i.e. on every hop.
    gui_hint: tabs@0:5,0,1,2
    label: CURRENT BAND
    type: string
    value: '''%.4f GHz'' % (center_freq/1e9)'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: |-
      Reported by the hopping block, not a control any more.
      The band list lives in the TwinRX Hopping USRP Source block.
    value: 2.4e9
  states: {}
- name: cmd_lead
  id: variable
  parameters:
    comment: |-
      How far ahead of "now" the timed tune is scheduled.
      Must exceed the host->FPGA latency. 0.1 s is safe.
    value: '0.1'
  states: {}
- name: disp_bw
  id: variable
  parameters:
    comment: |-
      Wide enough to keep the tone when the transmitter's crystal is off
      frequency. The HackRF is ~+/-20 ppm, which is ~116 kHz at 5.8 GHz,
      so the old 20 kHz window would have rejected it entirely.
    value: 300e3
  states: {}
- name: disp_gain
  id: variable
  parameters:
    comment: |-
      Fixed display gain for ch2/ch3.
      Replaces the AGC: the tone is already steady to ~0.6%, so no
      automatic gain is needed.  A fixed gain keeps the true relative
      amplitude between channels and has no start-up transient.
    value: '25'
  states: {}
- name: disp_interp_trans
  id: variable
  parameters:
    comment: |-
      Transition width of the display interpolator's anti-imaging filter.

      time_resamp_N interpolates 1 Msps up to time_srate purely so the time
      plot draws a smooth waveform. The filter only has to reject the images
      of the interpolated stream: the signal reaches disp_bw, the first image
      starts at samp_rate - disp_bw, so everything between the two is
      transition band and nothing is gained by making it narrower.

      It was fixed at 50 kHz, eight times tighter than that. Hamming taps go
      as 3.3 * fs / transition, so 50 kHz meant ~1320 taps running at 20 Msps
      on four channels -- 5.3 GMAC/s, measured as 527% CPU and a load average
      of 16 on a 12 core host, for a picture. A starved host is what makes
      the X310's RFNoC control acks time out, which is what kills the stream.
    value: samp_rate - 2 * disp_bw
  states: {}
- name: disp_taps_bp
  id: variable
  parameters:
    comment: |-
      One-sided: the tone always arrives on the positive side.
      Bands whose receive chain inverts the spectrum are pre-compensated at
      the transmitter -- 5.1 GHz is sent a -200 kHz tone so it still lands at
      +200 kHz (see --offset-map). Widening the filter to cover both sides
      would work too, but costs 3 dB of noise bandwidth to paper over
      something better fixed at the source.
    value: firdes.complex_band_pass(1.0, samp_rate, tone_offset - disp_bw/2, tone_offset + disp_bw/2, disp_bw/4, firdes.WIN_HAMMING)
  states: {}
- name: dsp_manual
  id: variable
  parameters:
    comment: |-
      True  -> force every DDC to 0 Hz so the digital
      down-conversion adds no per-channel phase.
      Set False if you need exact requested centre freq.
    value: 'True'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: |-
      TwinRX gain range is 0 .. 93 dB.
      60 dB is the best single setting for all three bands: it gives the most
      SNR on the weak ones (5.8 GHz reaches 45.7 dB) while 2.4 GHz still has
      about 4.8 dB of headroom. At 70 dB the 2.4 GHz band clips -- peak sample
      1.18 -- and its SNR drops from 81 to 69 dB through compression.
    gui_hint: tabs@0:1,0,1,2
    label: RX Gain (dB)
    min_len: '100'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '93'
    value: '60'
  states: {}
- name: lo_export_chan
  id: variable
  parameters:
    comment: |-
      Channel whose synthesiser feeds everything else.
      0 = DB-A ch0 exports (cables A->B)  -- NOT WORKING on this unit
      2 = DB-B ch0 exports (cables B->A)  -- verified working
    value: '2'
  states: {}
- name: lo_sources
  id: variable
  parameters:
    comment: |-
      Per-channel LO source, index = UHD channel.
      Master board : exporter = internal (or reimport), partner = companion
      Slave  board : BOTH channels = external
      Valid: internal / companion / external / reimport / disabled
      Rx B exports here, not Rx A. Measured on this unit the jumpers
      carrying A LO-out to B LO-in pass nothing, while B to A works.
      Swap back to [internal, companion, external, external] with
      lo_export_chan 0 if those cables get repaired.
    value: '[''external'', ''external'', ''internal'', ''companion'']'
  states: {}
- name: ph_avg
  id: variable
  parameters:
    comment: Averaging length for the displayed phase.
    value: '16384'
  states: {}
- name: ph_skip
  id: variable
  parameters:
    comment: |-
      Samples skipped before measuring, so the reading is
      past the start-up transient.
    value: 2**13
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Per-channel rate. 1 Msps x 4ch is easy on 10GbE
      and plenty for a phase-coherence check.
    value: '1000000'
  states: {}
- name: stream_state
  id: variable_qtgui_label
  parameters:
    comment: |-
      Says on screen whether the radio is actually sending.
      When the stream dies the traces hold their last value,
      which looks like a steady reading rather than no reading.
      The snippet below drives this from the block's watchdog.
    gui_hint: tabs@0:4,0,1,2
    label: STREAM
    type: string
    value: '''receiving'''
  states: {}
- name: subdev
  id: variable
  parameters:
    comment: |-
      DB-A = TwinRX #1 (ch0, ch1)
      DB-B = TwinRX #2 (ch2, ch3)
    value: '"A:0 A:1 B:0 B:1"'
  states: {}
- name: time_interp
  id: variable
  parameters:
    comment: Interpolation factor for time domain block
    value: '20'
  states: {}
- name: time_srate
  id: variable
  parameters:
    comment: Sampling rate specifically for time domain block (20 Msps)
    value: samp_rate * time_interp
  states: {}
- name: tone_bw
  id: variable
  parameters:
    comment: |-
      Half-width of the band kept around the tone, Hz.
      Narrow enough to reject DC and most of the noise, wide
      enough to tolerate the B210/X310 reference offset, which
      measured ~3.9 kHz at 2.4 GHz. 10 kHz halves the noise
      power the phase estimator sees versus the old 25 kHz.
    value: 10e3
  states: {}
- name: tone_offset
  id: variable
  parameters:
    comment: |-
      Baseband offset of the calibration tone, Hz.
      MUST match b210_tone_source.py --offset (default +200 kHz).
      Set 0 only if your source really is at the centre frequency,
      which makes it indistinguishable from LO leakage.
    value: 200e3
  states: {}
- name: tone_taps
  id: variable
  parameters:
    comment: Low-pass prototype for the translating filter.
    value: firdes.low_pass(1.0, samp_rate, tone_bw, tone_bw/2.0, firdes.WIN_HAMMING)
  states: {}
- name: tx_control
  id: variable
  parameters:
    comment: |-
      hackrf_tone_source.py control socket. The transmitter is told to
      retune first, so it is already there when we arrive.
      Set to '' to leave the transmitter alone.
    value: '''127.0.0.1:5123'''
  states: {}
- name: tx_disp_gain
  id: variable
  parameters:
    comment: |-
      Display-only gain for the black TX reference trace.
      The B210 TX sink in this flowgraph is DISABLED -- the real
      transmitter is b210_tone_source.py -- so this scales the
      on-screen trace only and cannot change radiated power.
    value: '10'
  states: {}
- name: view_decim
  id: variable
  parameters:
    comment: Decimation before the GUI sinks.
    value: '2048'
  states: {}
- name: bp_0
  id: fir_filter_xxx
  parameters:
    comment: Keep only the tone.
    decim: '1'
    taps: disp_taps_bp
    type: ccc
  states: {}
- name: bp_1
  id: fir_filter_xxx
  parameters:
    comment: Keep only the tone.
    decim: '1'
    taps: disp_taps_bp
    type: ccc
  states: {}
- name: bp_2
  id: fir_filter_xxx
  parameters:
    comment: Keep only the tone.
    decim: '1'
    taps: disp_taps_bp
    type: ccc
  states: {}
- name: bp_3
  id: fir_filter_xxx
  parameters:
    comment: Keep only the tone.
    decim: '1'
    taps: disp_taps_bp
    type: ccc
  states: {}
- name: c2r_0
  id: blocks_complex_to_real
  parameters:
    comment: Extract real part of Ch0 for time plot
  states: {}
- name: c2r_1
  id: blocks_complex_to_real
  parameters:
    comment: Extract real part of Ch1 for time plot
  states: {}
- name: c2r_2
  id: blocks_complex_to_real
  parameters:
    comment: Extract real part of Ch2 for time plot
  states: {}
- name: c2r_3
  id: blocks_complex_to_real
  parameters:
    comment: Extract real part of Ch3 for time plot
  states: {}
- name: dcblock_0
  id: dc_blocker_xx
  parameters:
    comment: Remove DC / LO leakage.
    length: '1024'
    long_form: 'True'
    type: cc
  states: {}
- name: dcblock_1
  id: dc_blocker_xx
  parameters:
    comment: Remove DC / LO leakage.
    length: '1024'
    long_form: 'True'
    type: cc
  states: {}
- name: dcblock_2
  id: dc_blocker_xx
  parameters:
    comment: Remove DC / LO leakage.
    length: '1024'
    long_form: 'True'
    type: cc
  states: {}
- name: dcblock_3
  id: dc_blocker_xx
  parameters:
    comment: Remove DC / LO leakage.
    length: '1024'
    long_form: 'True'
    type: cc
  states: {}
- name: disp_gate_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Blanks the plot while the radio settles.
    const: '0'
    type: complex
  states: {}
- name: disp_gate_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: Blanks the plot while the radio settles.
    const: '0'
    type: complex
  states: {}
- name: disp_gate_2
  id: blocks_multiply_const_vxx
  parameters:
    comment: Blanks the plot while the radio settles.
    const: '0'
    type: complex
  states: {}
- name: disp_gate_3
  id: blocks_multiply_const_vxx
  parameters:
    comment: Blanks the plot while the radio settles.
    const: '0'
    type: complex
  states: {}
- name: ph_avg_0
  id: blocks_moving_average_xx
  parameters:
    length: ph_avg
    max_iter: '65536'
    scale: 1.0/ph_avg
    type: float
  states: {}
- name: ph_avg_1
  id: blocks_moving_average_xx
  parameters:
    length: ph_avg
    max_iter: '65536'
    scale: 1.0/ph_avg
    type: float
  states: {}
- name: ph_avg_2
  id: blocks_moving_average_xx
  parameters:
    length: ph_avg
    max_iter: '65536'
    scale: 1.0/ph_avg
    type: float
  states: {}
- name: ph_avg_2_0
  id: blocks_moving_average_xx
  parameters:
    length: ph_avg
    max_iter: '65536'
    scale: 1.0/ph_avg
    type: float
  states: {}
- name: ph_dec_0
  id: blocks_keep_one_in_n
  parameters:
    n: '50000'
    type: float
  states: {}
- name: ph_dec_1
  id: blocks_keep_one_in_n
  parameters:
    n: '50000'
    type: float
  states: {}
- name: ph_dec_2
  id: blocks_keep_one_in_n
  parameters:
    n: '50000'
    type: float
  states: {}
- name: ph_dec_2_0
  id: blocks_keep_one_in_n
  parameters:
    n: '50000'
    type: float
  states: {}
- name: ph_deg_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      radians -> degrees (180/pi;
      GRC's evaluator has no math module)
    const: '-57.29577951308232'
    type: float
  states: {}
- name: ph_deg_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      radians -> degrees (180/pi;
      GRC's evaluator has no math module)
    const: '-57.29577951308232'
    type: float
  states: {}
- name: ph_deg_2
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      radians -> degrees (180/pi;
      GRC's evaluator has no math module)
    const: '-57.29577951308232'
    type: float
  states: {}
- name: ph_deg_2_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      radians -> degrees (180/pi;
      GRC's evaluator has no math module)
    const: '-57.29577951308232'
    type: float
  states: {}
- name: ph_est
  id: doa_twinrx_phase_offset_est
  parameters:
    comment: |-
      Phase of ch1/ch2/ch3 relative to ch0, in RADIANS.
      Raw channels, ahead of DC blocking and filtering.
    n_skip_ahead: ph_skip
    num_inputs: '5'
  states: {}
- name: ph_num_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tabs@0:7,1,1,1
    label1: ch0 - ch0
    max: '180'
    min: '-180'
    name: '"ch0 - ch0   phase offset (deg)"'
    type: float
    unit1: deg
    update_time: '0.20'
  states: {}
- name: ph_num_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tabs@0:8,1,1,1
    label1: ch1 - ch0
    max: '180'
    min: '-180'
    name: '"ch1 - ch0   phase offset (deg)"'
    type: float
    unit1: deg
    update_time: '0.20'
  states: {}
- name: ph_num_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tabs@0:9,1,1,1
    label1: ch2 - ch0
    max: '180'
    min: '-180'
    name: '"ch2- ch0   phase offset (deg)"'
    type: float
    unit1: deg
    update_time: '0.20'
  states: {}
- name: ph_num_2_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tabs@0:10,1,1,1
    label1: ch3 - ch0
    max: '180'
    min: '-180'
    name: '"ch3 - ch0   phase offset (deg)"'
    type: float
    unit1: deg
    update_time: '0.20'
  states: {}
- name: phase_correct_hopping_0
  id: phase_correct_hopping
  parameters:
    cal_file: '""'
    comment: |-
      Removes the fixed inter-channel offset, per band. Measured 2026-09-24 through this same radio configuration -- gains 46/60/69 and gain_trim (0, -13.3, 1.5, -1.7) -- because RX gain shifts phase here, so a table measured any other way does not apply. Verified: residuals -0.05..+0.23 deg on all three bands, against a measurement noise floor of 0.2-0.3 deg.
      VALID FOR THIS POWER SESSION ONLY. The LO dividers relock to a new phase every time the X310 is power cycled; re-run phase_table_measure.py after one, or these numbers silently correct to the wrong place.
    deg_0: (175.90, -86.62, -168.03)
    deg_1: (111.43, 71.93, 35.91)
    deg_2: (82.66, 155.54, 173.74)
    deg_3: (0.0, 0.0, 0.0)
    dwell_0: '10'
    dwell_1: '10'
    dwell_2: '10'
    dwell_3: '10'
    follow_source: 'True'
    freq_0: '2400000000'
    freq_1: '5200000000'
    freq_2: '5800000000'
    freq_3: '2400000000'
    freq_tol: '1000000'
    num_bands: '3'
    num_channels: '4'
    settle: '1.0'
    start_delay: '2.0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: |-
      Wideband view of what each channel actually receives: the tone,
      any LO leakage left after the DC blocker, and the noise floor.
      Taken before the display band-pass, so it shows the whole
      1 MHz span rather than just the tone.
    fc: center_freq
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: tabs@1:0,0,1,2
    label1: Ch0 RF A/RX1
    label2: Ch1 RF A/RX2
    label3: Ch2 RF B/RX1 (LO master)
    label4: Ch3 RF B/RX2
    name: '"Spectrum - all 4 channels (DC removed)"'
    nconnections: '4'
    type: complex
    width1: '2'
    width2: '2'
    width3: '2'
    width4: '2'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-20'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    color1: red
    color2: blue
    color4: magenta
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: tabs@0:6,0,1,2
    label1: Ch0 RF A/RX2 - LO external
    label2: Ch1 RF A/RX1 - LO external
    label3: Ch2 RF B/RX1 - LO internal (MASTER, exports)
    label4: Ch3 RF B/RX2 - LO companion
    name: '"RF Waveforms - all 4 channels: DC removed, tone filtered, uniform gain"'
    nconnections: '4'
    size: '1000'
    srate: time_srate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    width1: '2'
    width2: '2'
    width3: '2'
    width4: '2'
    ymax: '0.6'
    ymin: '-0.6'
  states: {}
- name: snippet_hop
  id: snippet
  parameters:
    code: |
      # Follows the hopping block: keeps the CURRENT BAND label in step, and
      # blanks the time plot while the radio settles after a hop.
      #
      # Only the display path is gated. Muting the samples themselves also fed
      # zeros to the phase estimator, which then read a clean +0.00 deg -- a
      # perfectly steady number from no signal at all, which is the one reading
      # this bench must never produce.
      #
      # This polls on a Qt timer, not a Python thread, because it touches Qt.
      # set_center_freq -> qtgui_freq_sink_x_0.set_frequency_range() reaches
      # into the plot widget, and Qt objects may only be touched from the
      # thread that owns them. Driven from a worker thread it logs
      # "QCoreApplication::sendPostedEvents: Cannot send posted events for
      # objects in another thread" on every hop -- measured at 47 in a 9 minute
      # run -- and the documented outcome of ignoring that ranges from a
      # corrupted widget to a frozen event loop. A QTimer owned by the GUI
      # thread runs the same poll with every Qt call on the right thread.
      #
      # Everything called here is a cheap attribute read or a block setter.
      # Nothing in this function may block: it now runs on the GUI thread, so
      # anything slow here freezes the window it is meant to be updating.
      from PyQt5 import QtCore

      self._hop_run = True
      _gates = [self.disp_gate_0, self.disp_gate_1,
                self.disp_gate_2, self.disp_gate_3,
                self.spec_gate_0, self.spec_gate_1,
                self.spec_gate_2, self.spec_gate_3]

      self._follow_state = {'band': None, 'open': None, 'stream': None}

      def _follow():
          st = self._follow_state
          if not st.get('ticked'):
              st['ticked'] = True
              print('[follow] timer is running')
          try:
              b = self.twinrx_hopping_source_0.get_current_band()
              settled = self.twinrx_hopping_source_0.is_settled()
          except Exception as e:
              # Say it once. Swallowing this silently leaves the phase correction
              # sitting at its startup state -- no rotation at all -- while the
              # flowgraph looks like it is running normally and the offsets read as
              # though nothing were calibrated. That is exactly how it hid.
              if not st.get('read_failed'):
                  st['read_failed'] = True
                  print('[follow] CANNOT READ THE BAND: %s: %s'
                        % (type(e).__name__, e))
                  print('[follow] phase correction stays OFF until this is fixed')
              b, settled = None, True
          if b is not None and b != st['band']:
              st['band'] = b
              self.set_center_freq(b[0])
              # Keep the phase correction on the same band as the radio. It is
              # told, not timed: a correction block keeping its own clock would
              # eventually apply one band's table while the radio sits on
              # another, and the readouts would look clean the whole time.
              try:
                  self.phase_correct_hopping_0.set_band_freq(b[0])
              except Exception as e:
                  print('[phasecal] could not follow the band: %s' % e)
          if settled != st['open']:
              st['open'] = settled
              for g in _gates:
                  g.set_k(1.0 if settled else 0.0)
          try:
              alive = self.twinrx_hopping_source_0.stream_is_alive()
              stalls = self.twinrx_hopping_source_0.get_stream_stalls()
          except Exception as e:
              # Not 'assume healthy'. Claiming the stream is receiving when the
              # block could not be asked is the one thing this label exists to
              # prevent: a frozen reading that looks like a stable measurement.
              alive, stalls = None, 0
              if not st.get('stream_read_failed'):
                  st['stream_read_failed'] = True
                  print('[follow] cannot read the stream state: %s: %s'
                        % (type(e).__name__, e))
          state = ('receiving' if alive else
                   'UNKNOWN - cannot read the stream state' if alive is None else
                   'STOPPED - the radio is not sending, nothing below is a reading')
          if stalls:
              state += '   (recovered %d time(s) this run)' % stalls
          if state != st['stream']:
              st['stream'] = state
              self.set_stream_state(state)

      self._follow_timer = QtCore.QTimer(self)
      self._follow_timer.timeout.connect(_follow)
      self._follow_timer.start(50)
      print('[follow] timer created: active=%s interval=%s thread=%s'
            % (self._follow_timer.isActive(), self._follow_timer.interval(),
               QtCore.QThread.currentThread()))
    comment: |-
      Follows the block so the CURRENT BAND label
      tracks; the block does the hopping itself.
    section: main_after_start
  states: {}
- name: snippet_lo_config
  id: snippet
  parameters:
    code: |
      # LO routing and the timed tune happen INSIDE the TwinRX USRP Source
      # block, so nothing LO-related belongs here.
      #
      # The calibration source is a HackRF One, started outside this flowgraph
      # (run_hop.sh, or: hackrf --freq 2.4e9 --vga 16). It cannot be launched
      # from here: the HackRF needs the system GNU Radio 3.10 while this runs
      # under 3.8, and keeping libuhd 4.1 out of the transmitter's process
      # matters because the X310's FPGA image is built for UHD 3.15.
      print('[*] Calibration source: HackRF One (started separately).')
    comment: The transmitter runs in its own process; see run_hop.sh.
    section: main_after_init
  states: {}
- name: snippet_lo_stop
  id: snippet
  parameters:
    code: |
      # Stop the block's hop thread BEFORE the flowgraph tears down.
      #
      # It lives inside the source block and checks that block's own flag, so
      # setting a flag on the top block here did nothing. The thread kept
      # issuing timed tune commands while the USRP object was being destroyed,
      # which left the X310's RFNoC control plane wedged -- recoverable only by
      # power cycling the radio.
      try:
          self.twinrx_hopping_source_0.stop_hopping()
          print('Hop thread stopped.')
      except Exception as e:
          print('Could not stop the hop thread: %s' % e)
      self._hop_run = False
      # The display poll is a Qt timer now. Left running it would keep calling
      # into blocks that are being torn down.
      try:
          self._follow_timer.stop()
      except Exception:
          pass
      self._twinrx_run = False
    comment: |-
      Stops hopping before teardown -- otherwise the thread
      tunes a device that is being destroyed.
    section: main_after_stop
  states: {}
- name: snippet_lo_watch
  id: snippet
  parameters:
    code: |
      print('TwinRX USRP Source block owns LO routing and tuning.')
    section: main_after_start
  states: {}
- name: spec_gate_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Blanks the spectrum while the radio settles,
      same as the time plot.
    const: '0'
    type: complex
  states: {}
- name: spec_gate_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Blanks the spectrum while the radio settles,
      same as the time plot.
    const: '0'
    type: complex
  states: {}
- name: spec_gate_2
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Blanks the spectrum while the radio settles,
      same as the time plot.
    const: '0'
    type: complex
  states: {}
- name: spec_gate_3
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Blanks the spectrum while the radio settles,
      same as the time plot.
    const: '0'
    type: complex
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Control & Phase
    label1: Spectra
    num_tabs: '2'
  states: {}
- name: time_resamp_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: time_interp
    taps: firdes.low_pass(time_interp * disp_gain, time_srate, disp_bw, disp_interp_trans, firdes.WIN_HAMMING)
    type: ccc
  states: {}
- name: time_resamp_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: time_interp
    taps: firdes.low_pass(time_interp * disp_gain, time_srate, disp_bw, disp_interp_trans, firdes.WIN_HAMMING)
    type: ccc
  states: {}
- name: time_resamp_2
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: time_interp
    taps: firdes.low_pass(time_interp * disp_gain, time_srate, disp_bw, disp_interp_trans, firdes.WIN_HAMMING)
    type: ccc
  states: {}
- name: time_resamp_3
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: time_interp
    taps: firdes.low_pass(time_interp * disp_gain, time_srate, disp_bw, disp_interp_trans, firdes.WIN_HAMMING)
    type: ccc
  states: {}
- name: twinrx_hopping_source_0
  id: twinrx_hopping_source
  parameters:
    addresses: '"type=x300"'
    blank_during_settle: 'False'
    comment: |-
      Bands 2.4 / 5.2 / 5.8 GHz. None of them needs the LO fallback: 5.2 GHz
      uses a low-side LO natively, unlike 5.1 GHz where UHD picks a high-side
      LO the synthesiser will not re-lock to. So no forced re-lock, no mirrored
      spectrum, and no 180 degree step on the exporting channel.

      LO must be exported by Rx B: the A->B MMCX jumpers pass no LO, so
      direction 'A' leaves ch2/ch3 with no oscillator and two flat traces.
    cpu_format: fc32
    dwell_0: '10.0'
    dwell_1: '10.0'
    dwell_2: '10.0'
    dwell_3: '10.0'
    dwell_4: '10.0'
    dwell_5: '10.0'
    dwell_6: '10.0'
    dwell_7: '10.0'
    freq_0: '2400000000'
    freq_1: '5200000000'
    freq_2: '5800000000'
    freq_3: '2400000000'
    freq_4: '2400000000'
    freq_5: '2400000000'
    freq_6: '2400000000'
    freq_7: '2400000000'
    gain_0: '46'
    gain_1: '60'
    gain_2: '69'
    gain_3: '60'
    gain_4: '60'
    gain_5: '60'
    gain_6: '60'
    gain_7: '60'
    gain_trim: (0.0, -13.3, 1.5, -1.7)
    hop_enable: 'True'
    lo_export_direction: B
    lo_lock_fallback: 'False'
    num_bands: '3'
    otw_format: ''
    recv_buff_size: '33554432'
    samp_rate: '1000000'
    settle: '1.0'
    sources: '4'
    start_delay: '2.0'
    stream_timeout: '3.0'
    tx_control: '"127.0.0.1:5123"'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX1
    ant1: RX2
    ant2: RX1
    ant3: RX2
    center_freq0: center_freq
    center_freq1: center_freq
    center_freq2: center_freq
    center_freq3: center_freq
    clock_rate: 200e6
    clock_source0: internal
    comment: |-
      TwinRX REQUIRES master_clock_rate = 200 MHz.
      LO controls are deliberately hidden here: GRC would emit
      set_lo_source() AFTER set_center_freq(), which is the wrong
      order.  The Python Snippet does it properly instead.
    dc_offs_enb0: ''
    dc_offs_enb1: ''
    dc_offs_enb2: ''
    dc_offs_enb3: ''
    dev_addr: '"type=x300"'
    dev_args: '""'
    gain0: gain
    gain1: gain
    gain2: gain
    gain3: gain
    iq_imbal_enb0: ''
    iq_imbal_enb1: ''
    iq_imbal_enb2: ''
    iq_imbal_enb3: ''
    nchan: '4'
    norm_gain0: 'False'
    norm_gain1: 'False'
    norm_gain2: 'False'
    norm_gain3: 'False'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sd_spec0: subdev
    sync: none
    time_source0: internal
    type: fc32
  states: {state: disabled}

connections:
- [bp_0, '0', phase_correct_hopping_0, '0']
- [bp_1, '0', phase_correct_hopping_0, '3']
- [bp_2, '0', phase_correct_hopping_0, '1']
- [bp_3, '0', phase_correct_hopping_0, '2']
- [c2r_0, '0', qtgui_time_sink_x_1, '0']
- [c2r_1, '0', qtgui_time_sink_x_1, '3']
- [c2r_2, '0', qtgui_time_sink_x_1, '1']
- [c2r_3, '0', qtgui_time_sink_x_1, '2']
- [dcblock_0, '0', bp_0, '0']
- [dcblock_0, '0', spec_gate_0, '0']
- [dcblock_1, '0', bp_1, '0']
- [dcblock_1, '0', spec_gate_1, '0']
- [dcblock_2, '0', bp_2, '0']
- [dcblock_2, '0', spec_gate_2, '0']
- [dcblock_3, '0', bp_3, '0']
- [dcblock_3, '0', spec_gate_3, '0']
- [disp_gate_0, '0', time_resamp_0, '0']
- [disp_gate_1, '0', time_resamp_1, '0']
- [disp_gate_2, '0', time_resamp_2, '0']
- [disp_gate_3, '0', time_resamp_3, '0']
- [ph_avg_0, '0', ph_dec_0, '0']
- [ph_avg_1, '0', ph_dec_1, '0']
- [ph_avg_2, '0', ph_dec_2, '0']
- [ph_avg_2_0, '0', ph_dec_2_0, '0']
- [ph_dec_0, '0', ph_num_0, '0']
- [ph_dec_1, '0', ph_num_1, '0']
- [ph_dec_2, '0', ph_num_2, '0']
- [ph_dec_2_0, '0', ph_num_2_0, '0']
- [ph_deg_0, '0', ph_avg_0, '0']
- [ph_deg_1, '0', ph_avg_1, '0']
- [ph_deg_2, '0', ph_avg_2, '0']
- [ph_deg_2_0, '0', ph_avg_2_0, '0']
- [ph_est, '0', ph_deg_0, '0']
- [ph_est, '1', ph_deg_1, '0']
- [ph_est, '2', ph_deg_2, '0']
- [ph_est, '3', ph_deg_2_0, '0']
- [phase_correct_hopping_0, '0', disp_gate_0, '0']
- [phase_correct_hopping_0, '0', ph_est, '0']
- [phase_correct_hopping_0, '0', ph_est, '1']
- [phase_correct_hopping_0, '1', disp_gate_2, '0']
- [phase_correct_hopping_0, '1', ph_est, '2']
- [phase_correct_hopping_0, '2', disp_gate_3, '0']
- [phase_correct_hopping_0, '2', ph_est, '3']
- [phase_correct_hopping_0, '3', disp_gate_1, '0']
- [phase_correct_hopping_0, '3', ph_est, '4']
- [spec_gate_0, '0', qtgui_freq_sink_x_0, '0']
- [spec_gate_1, '0', qtgui_freq_sink_x_0, '3']
- [spec_gate_2, '0', qtgui_freq_sink_x_0, '1']
- [spec_gate_3, '0', qtgui_freq_sink_x_0, '2']
- [time_resamp_0, '0', c2r_0, '0']
- [time_resamp_1, '0', c2r_1, '0']
- [time_resamp_2, '0', c2r_2, '0']
- [time_resamp_3, '0', c2r_3, '0']
- [twinrx_hopping_source_0, '0', dcblock_0, '0']
- [twinrx_hopping_source_0, '1', dcblock_2, '0']
- [twinrx_hopping_source_0, '2', dcblock_3, '0']
- [twinrx_hopping_source_0, '3', dcblock_1, '0']

metadata:
  file_format: 1
